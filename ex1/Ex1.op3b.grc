<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.9'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>Lab_total</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>run</key><value>run_stop</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>Ensayos</value></param>
<param><key>value</key><value>1000000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>Fc</value></param>
<param><key>value</key><value>80e6</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>Gain_USRP_Rx_dB</value></param>
<param><key>value</key><value>0.</value></param>
<param><key>gui_hint</key><value>0,5,1,1</value></param>
<param><key>label</key><value>USRPRxGain(dB)</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0.</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>30</value></param>
<param><key>widget</key><value>counter</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>Gain_USRP_Tx_dB</value></param>
<param><key>value</key><value>10.</value></param>
<param><key>gui_hint</key><value>0,4,1,1</value></param>
<param><key>label</key><value>USRPTxGain(dB)</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0.</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>30</value></param>
<param><key>widget</key><value>counter</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>Krx</value></param>
<param><key>value</key><value>128</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>Krx_d</value></param>
<param><key>value</key><value>samp_rate_usrp_rx/samp_rate_d</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>Ktx</value></param>
<param><key>value</key><value>512</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>Ktx_d</value></param>
<param><key>value</key><value>samp_rate_usrp_tx/samp_rate_d</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>N</value></param>
<param><key>value</key><value>1024</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>NbpS</value></param>
<param><key>value</key><value>8</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>NnivelesQ</value></param>
<param><key>value</key><value>math.pow(2,NbpS)</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>NodB</value></param>
<param><key>value</key><value>-60</value></param>
<param><key>gui_hint</key><value>0,1,1,1</value></param>
<param><key>label</key><value>No (dB)</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>-140.</value></param>
<param><key>step</key><value>1.</value></param>
<param><key>stop</key><value>0.</value></param>
<param><key>widget</key><value>counter</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>Rb</value></param>
<param><key>value</key><value>NbpS*samp_rate_audio</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>Rs</value></param>
<param><key>value</key><value>Rb</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>RxGain_dB</value></param>
<param><key>value</key><value>0</value></param>
<param><key>gui_hint</key><value>0,2,1,1</value></param>
<param><key>label</key><value>RxGain(dB)</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>1.</value></param>
<param><key>stop</key><value>100</value></param>
<param><key>widget</key><value>counter</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>Scramb_Delay</value></param>
<param><key>value</key><value>0</value></param>
<param><key>gui_hint</key><value>0,6,1,1</value></param>
<param><key>label</key><value>Scr_Delay</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>Sps*8</value></param>
<param><key>rangeType</key><value>int</value></param>
<param><key>widget</key><value>counter</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>Sps</value></param>
<param><key>value</key><value>4</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>Tmax_scope</value></param>
<param><key>value</key><value>16./samp_rate_audio</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>Vp</value></param>
<param><key>value</key><value>0.6</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>phi_ajuste</value></param>
<param><key>value</key><value>0.</value></param>
<param><key>gui_hint</key><value>0,3,1,1</value></param>
<param><key>label</key><value>phi (Rad)</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>-2.*math.pi</value></param>
<param><key>step</key><value>4*math.pi/200.</value></param>
<param><key>stop</key><value>2.*math.pi</value></param>
<param><key>widget</key><value>counter</value></param>
</block>
<block>
<key>variable_qtgui_check_box</key>
<param><key>id</key><value>run_stop</value></param>
<param><key>value</key><value>True</value></param>
<param><key>false</key><value>False</value></param>
<param><key>gui_hint</key><value>0,0,1,1</value></param>
<param><key>label</key><value>Inicial/Parar</value></param>
<param><key>true</key><value>True</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate_audio</value></param>
<param><key>value</key><value>22000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate_d</value></param>
<param><key>value</key><value>Rs*Sps</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate_rx</value></param>
<param><key>value</key><value>int(100e6/Krx)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate_tx</value></param>
<param><key>value</key><value>int(400e6/Ktx)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate_usrp_rx</value></param>
<param><key>value</key><value>100e6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate_usrp_tx</value></param>
<param><key>value</key><value>400e6</value></param>
</block>
<block>
<key>qtgui_tab_widget</key>
<param><key>id</key><value>Instrumentos</value></param>
<param><key>gui_hint</key><value>1,0,1,7</value></param>
<param><key>label0</key><value>Capa8.Mensaje continuo</value></param>
<param><key>label1</key><value>Capa7.Cuantificacion</value></param>
<param><key>label2</key><value>Capa6.PCM</value></param>
<param><key>label3</key><value>Capa5.Energy Dispersal</value></param>
<param><key>label4</key><value>Capa4-Modulacion</value></param>
<param><key>label5</key><value>Capa0.1. Precanal1</value></param>
<param><key>label6</key><value>Capa0.3. Contacto con USRP</value></param>
<param><key>num_tabs</key><value>7</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>Rx_1_0_0_1</value></param>
<param><key>stream_id</key><value>R7</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>Tx_1_0</value></param>
<param><key>stream_id</key><value>T8</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>Tx_1_0_0</value></param>
<param><key>stream_id</key><value>T7</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>Tx_1_0_0_0</value></param>
<param><key>stream_id</key><value>R8</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>Tx_1_0_0_1_0_0</value></param>
<param><key>stream_id</key><value>R6</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>Tx_1_0_0_2_0</value></param>
<param><key>stream_id</key><value>T6</value></param>
</block>
<block>
<key>audio_sink</key>
<param><key>id</key><value>audio_sink_0</value></param>
<param><key>samp_rate</key><value>samp_rate_audio</value></param>
</block>
<block>
<key>audio_source</key>
<param><key>id</key><value>audio_source_0</value></param>
<param><key>samp_rate</key><value>samp_rate_audio</value></param>
</block>
<block>
<key>b_PSD_VRMS</key>
<param><key>id</key><value>b_PSD_VRMS_0</value></param>
<param><key>Amp</key><value>1.5</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>samp_rate_audio</key><value>Rb</value></param>
<param><key>gui_hint</key><value>Instrumentos@3:0,2,1,1</value></param>
<param><key>N</key><value>1024</value></param>
<param><key>Ensayos</key><value>1000000</value></param>
</block>
<block>
<key>b_PSD_VRMS_2ways</key>
<param><key>id</key><value>b_PSD_VRMS_2ways_0</value></param>
<param><key>Amp</key><value>0.3</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>samp_rate_audio</key><value>samp_rate_audio</value></param>
<param><key>gui_hint</key><value>Instrumentos@0:0,2,1,1</value></param>
<param><key>N</key><value>1024</value></param>
<param><key>Ensayos</key><value>1000000</value></param>
</block>
<block>
<key>b_PSD_VRMS_2ways</key>
<param><key>id</key><value>b_PSD_VRMS_2ways_0_0</value></param>
<param><key>Amp</key><value>1.5</value></param>
<param><key>samp_rate_audio</key><value>Rb</value></param>
<param><key>gui_hint</key><value>Instrumentos@2:0,0</value></param>
<param><key>N</key><value>1024</value></param>
<param><key>Ensayos</key><value>1000000</value></param>
</block>
<block>
<key>b_PSD_VRMS_2ways_c</key>
<param><key>id</key><value>b_PSD_VRMS_2ways_c_0</value></param>
<param><key>Amp</key><value>1.5</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>samp_rate_audio</key><value>Rs</value></param>
<param><key>gui_hint</key><value>Instrumentos@4:0,2,1,1</value></param>
<param><key>N</key><value>1024</value></param>
<param><key>Ensayos</key><value>1000000</value></param>
</block>
<block>
<key>b_PSD_VRMS_2ways_c</key>
<param><key>id</key><value>b_PSD_VRMS_2ways_c_0_0</value></param>
<param><key>Amp</key><value>1.5</value></param>
<param><key>samp_rate_audio</key><value>samp_rate_d</value></param>
<param><key>gui_hint</key><value>Instrumentos@5:0,2,1,1</value></param>
<param><key>N</key><value>1024</value></param>
<param><key>Ensayos</key><value>1000000</value></param>
</block>
<block>
<key>b_PSD_VRMS_2ways_c</key>
<param><key>id</key><value>b_PSD_VRMS_2ways_c_0_0_0</value></param>
<param><key>Amp</key><value>1.5</value></param>
<param><key>samp_rate_audio</key><value>samp_rate_tx</value></param>
<param><key>gui_hint</key><value>Instrumentos@6:0,2,1,1</value></param>
<param><key>N</key><value>1024</value></param>
<param><key>Ensayos</key><value>1000000</value></param>
</block>
<block>
<key>b_quantizer_fb</key>
<param><key>id</key><value>b_quantizer_fb_0</value></param>
<param><key>NivelesQ</key><value>NnivelesQ</value></param>
<param><key>Vmax</key><value>Vp</value></param>
</block>
<block>
<key>blocks_char_to_float</key>
<param><key>id</key><value>blocks_char_to_float_0</value></param>
<param><key>scale</key><value>1</value></param>
</block>
<block>
<key>blocks_char_to_float</key>
<param><key>id</key><value>blocks_char_to_float_0_0</value></param>
<param><key>scale</key><value>1</value></param>
</block>
<block>
<key>blocks_char_to_float</key>
<param><key>id</key><value>blocks_char_to_float_0_0_0</value></param>
<param><key>scale</key><value>1</value></param>
</block>
<block>
<key>blocks_char_to_float</key>
<param><key>id</key><value>blocks_char_to_float_0_0_0_0</value></param>
<param><key>scale</key><value>1</value></param>
</block>
<block>
<key>blocks_delay</key>
<param><key>id</key><value>blocks_delay_0</value></param>
<param><key>delay</key><value>Scramb_Delay</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>blocks_float_to_char</key>
<param><key>id</key><value>blocks_float_to_char_0</value></param>
<param><key>scale</key><value>1</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0_0_0</value></param>
<param><key>const</key><value>Vp/(NnivelesQ/2)</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_pack_k_bits_bb</key>
<param><key>id</key><value>blocks_pack_k_bits_bb_0</value></param>
<param><key>k</key><value>NbpS</value></param>
</block>
<block>
<key>blocks_unpack_k_bits_bb</key>
<param><key>id</key><value>blocks_unpack_k_bits_bb_0_1</value></param>
<param><key>k</key><value>NbpS</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>e1_0_0_0_0_0_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>stream_id</key><value>T5</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>e1_0_0_0_0_0_0_0</value></param>
<param><key>stream_id</key><value>T6</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>e1_0_0_0_0_0_0_0_0</value></param>
<param><key>stream_id</key><value>R6</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>e1_0_0_0_0_0_0_1</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>stream_id</key><value>T8</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>e1_0_0_0_0_0_0_1_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>stream_id</key><value>R8</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>e1_0_0_0_0_0_0_1_0_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>stream_id</key><value>R4</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>e1_0_0_0_0_0_0_1_0_0_0</value></param>
<param><key>stream_id</key><value>R0.1</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>e1_0_0_0_0_0_0_1_0_0_0_0</value></param>
<param><key>stream_id</key><value>R0.3</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>e1_0_0_0_0_0_0_1_1</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>stream_id</key><value>T4</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>e1_0_0_0_0_0_0_1_1_0</value></param>
<param><key>stream_id</key><value>T0.1</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>e1_0_0_0_0_0_0_1_1_0_0</value></param>
<param><key>stream_id</key><value>T0.3</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0_1</value></param>
<param><key>import</key><value>import cmath</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0_1_0</value></param>
<param><key>import</key><value>import numpy</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0_1_0_0</value></param>
<param><key>import</key><value>import random</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0_1_1</value></param>
<param><key>import</key><value>import math</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_0</value></param>
<param><key>note</key><value>CAPA8 MENSAJE</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_0_0</value></param>
<param><key>note</key><value>CAPA7 CUANTIFICACION</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_0_0_1_2</value></param>
<param><key>note</key><value>INSTRUMENTACION</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_0_0_2</value></param>
<param><key>note</key><value>CAPA6 PCM</value></param>
</block>
<connection><source_block_id>audio_source_0</source_block_id><sink_block_id>Tx_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>audio_source_0</source_block_id><sink_block_id>b_quantizer_fb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>b_quantizer_fb_0</source_block_id><sink_block_id>Tx_1_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>b_quantizer_fb_0</source_block_id><sink_block_id>blocks_unpack_k_bits_bb_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_char_to_float_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_char_to_float_0_0</source_block_id><sink_block_id>Tx_1_0_0_1_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_char_to_float_0_0</source_block_id><sink_block_id>Tx_1_0_0_2_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_char_to_float_0_0</source_block_id><sink_block_id>blocks_float_to_char_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_char_to_float_0_0_0</source_block_id><sink_block_id>b_PSD_VRMS_2ways_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_char_to_float_0_0_0_0</source_block_id><sink_block_id>b_PSD_VRMS_2ways_0_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_delay_0</source_block_id><sink_block_id>blocks_char_to_float_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_float_to_char_0</source_block_id><sink_block_id>blocks_pack_k_bits_bb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0_0_0</source_block_id><sink_block_id>Tx_1_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0_0_0</source_block_id><sink_block_id>audio_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_pack_k_bits_bb_0</source_block_id><sink_block_id>Rx_1_0_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_pack_k_bits_bb_0</source_block_id><sink_block_id>blocks_char_to_float_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_unpack_k_bits_bb_0_1</source_block_id><sink_block_id>blocks_char_to_float_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>e1_0_0_0_0_0_0</source_block_id><sink_block_id>b_PSD_VRMS_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>e1_0_0_0_0_0_0_0</source_block_id><sink_block_id>blocks_delay_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>e1_0_0_0_0_0_0_0_0</source_block_id><sink_block_id>blocks_char_to_float_0_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>e1_0_0_0_0_0_0_1</source_block_id><sink_block_id>b_PSD_VRMS_2ways_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>e1_0_0_0_0_0_0_1_0</source_block_id><sink_block_id>b_PSD_VRMS_2ways_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>e1_0_0_0_0_0_0_1_0_0</source_block_id><sink_block_id>b_PSD_VRMS_2ways_c_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>e1_0_0_0_0_0_0_1_0_0_0</source_block_id><sink_block_id>b_PSD_VRMS_2ways_c_0_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>e1_0_0_0_0_0_0_1_0_0_0_0</source_block_id><sink_block_id>b_PSD_VRMS_2ways_c_0_0_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>e1_0_0_0_0_0_0_1_1</source_block_id><sink_block_id>b_PSD_VRMS_2ways_c_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>e1_0_0_0_0_0_0_1_1_0</source_block_id><sink_block_id>b_PSD_VRMS_2ways_c_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>e1_0_0_0_0_0_0_1_1_0_0</source_block_id><sink_block_id>b_PSD_VRMS_2ways_c_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
