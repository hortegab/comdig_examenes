options:
  parameters:
    generate_options: qt_gui
    id: top_block
    output_language: python
    run: run_stop
  states: {}

blocks:
- name: B
  id: variable
  parameters:
    value: 240e6
  states: {}
- name: BW
  id: variable
  parameters:
    value: Fmax
  states: {}
- name: Channel_BW
  id: variable
  parameters:
    value: Fmax
  states: {}
- name: Channel_BW_P4
  id: variable
  parameters:
    value: W
  states: {}
- name: Delay_ch
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,5,1,1
    label: Delay_ch
    orient: Qt.Horizontal
    rangeType: int
    start: '0'
    step: '1'
    stop: '64'
    value: '33'
  states: {}
- name: F_Resolucion
  id: variable
  parameters:
    value: B/N
  states: {}
- name: Fmax
  id: variable
  parameters:
    value: B/2
  states: {}
- name: N
  id: variable
  parameters:
    value: '1024'
  states: {}
- name: Nlobf
  id: variable
  parameters:
    value: '8'
  states: {}
- name: No_dB
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,4,1,1
    label: No (dB)
    orient: Qt.Horizontal
    start: '-300'
    step: 300/100.
    stop: '0'
    value: '-300'
  states: {}
- name: Rb
  id: variable
  parameters:
    value: B/Nlobf
  states: {}
- name: Retardo_Timing
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,3,1,1
    label: Timing
    orient: Qt.Horizontal
    rangeType: int
    start: '0'
    step: '1'
    stop: Sps-1
    value: '7'
  states: {}
- name: Retardo_ojo
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,1,1,1
    label: Center the Eye by a delay
    orient: Qt.Horizontal
    rangeType: int
    start: '0'
    step: '1'
    stop: Sps*2
    value: '0'
    widget: counter
  states: {}
- name: Retardo_ojo_t
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,2,1,1
    label: Center the Eye-Timing Diagramm
    orient: Qt.Horizontal
    rangeType: int
    start: '0'
    step: '1'
    stop: Sps*2
    value: '8'
    widget: counter
  states: {}
- name: Sps
  id: variable
  parameters:
    value: int(samp_rate/Rb)
  states: {}
- name: W
  id: variable
  parameters:
    value: Rb/2
  states: {}
- name: bits_afectados_por_ISI
  id: variable
  parameters:
    value: int(ntaps/Sps)-1
  states: {}
- name: h
  id: variable
  parameters:
    value: wform.rect(Sps)
  states: {}
- name: ntaps
  id: variable
  parameters:
    value: Sps*1
  states: {}
- name: run_stop
  id: variable_qtgui_check_box
  parameters:
    'false': 'False'
    gui_hint: 0,0,1,1
    label: Pause
    'true': 'True'
    type: int
    value: 'True'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: Fmax*2
  states: {}
- name: E3TRadio_bipolar_decisor_ff_0
  id: E3TRadio_bipolar_decisor_ff
  parameters: {}
  states: {}
- name: E3TRadio_bipolar_decisor_ff_0_0
  id: E3TRadio_bipolar_decisor_ff
  parameters: {}
  states: {}
- name: E3TRadio_diezma_ff_0
  id: E3TRadio_diezma_ff
  parameters:
    M: '2'
    N: Sps
  states: {}
- name: E3TRadio_diezma_ff_0_0
  id: E3TRadio_diezma_ff
  parameters:
    M: Retardo_Timing
    N: Sps
  states: {}
- name: analog_const_source_x_0_2_0
  id: analog_const_source_x
  parameters:
    const: samp_rate/1e6
    type: float
  states: {}
- name: analog_const_source_x_0_2_0_0
  id: analog_const_source_x
  parameters:
    const: Rb/1e6
    type: float
  states: {}
- name: analog_const_source_x_0_2_0_0_0
  id: analog_const_source_x
  parameters:
    const: Channel_BW/1e6
    type: float
  states: {}
- name: b_Canal_AWGN_ff_0
  id: b_Canal_AWGN_ff
  parameters:
    BW: Channel_BW
    Ch_NodB: No_dB
    Ch_Toffset: '0'
    samp_rate: samp_rate
  states: {}
- name: b_Canal_AWGN_ff_0_0
  id: b_Canal_AWGN_ff
  parameters:
    BW: Channel_BW_P4
    Ch_NodB: No_dB
    Ch_Toffset: '0'
    samp_rate: samp_rate
  states: {}
- name: b_EYE_Timing_f_0
  id: b_EYE_Timing_f
  parameters:
    AlphaLineas: '0.5'
    Delay: Retardo_ojo_t
    GrosorLineas: '20'
    N_eyes: '2'
    Retardo_Timing: Retardo_Timing
    Samprate: samp_rate
    Sps: Sps
    Title: '"Diagrama de ojo en R4 (modificado)"'
    Ymax: '2'
    Ymin: '-2'
    gui_hint: menu@5:0,0,1,1
  states: {}
- name: b_Eye_Diagram_simple_f_0
  id: b_Eye_Diagram_simple_f
  parameters:
    AlphaLineas: '0.5'
    Delay_i: '4'
    GrosorLineas: '20'
    N_eyes: '2'
    Samprate: samp_rate
    Sps: Sps
    Title: '"Diagrama de ojo en T4"'
    Ymax: '2'
    Ymin: '-2'
    gui_hint: menu@4:0,0,1,1
  states: {}
- name: b_PSD_0_0_0
  id: b_PSD
  parameters:
    Ensayos: '1000000'
    N: '1024'
    Titulo: '''PSD in  R4'''
    Ymax: '1e-5'
    gui_hint: menu@0:3,0,1,1
    samp_rate_audio: samp_rate
  states: {}
- name: b_binary_bipolar_source1_f_0
  id: b_binary_bipolar_source1_f
  parameters:
    Am: '1.'
  states: {}
- name: b_eye_diagram_f_0
  id: b_eye_diagram_f
  parameters:
    Delay: Retardo_ojo
    Sps: Sps
    samp_rate: samp_rate
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: Delay_ch
    type: float
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: import_0_0
  id: import
  parameters:
    imports: import numpy
  states: {}
- name: interp_fir_filter_xxx_0
  id: interp_fir_filter_xxx
  parameters:
    interp: Sps
    taps: h
    type: fff
  states: {}
- name: menu
  id: qtgui_tab_widget
  parameters:
    gui_hint: 2,0,1,6
    label0: Datos de Entrada
    label1: P1
    label2: P2
    label3: P3
    label4: P4a
    label5: P4b
    num_tabs: '6'
  states: {}
- name: note_0
  id: note
  parameters:
    note: Datos de entrada
  states: {}
- name: note_0_0_0
  id: note
  parameters:
    note: P1
  states: {}
- name: note_0_0_0_2
  id: note
  parameters:
    note: P2
  states: {}
- name: note_0_0_0_2_0
  id: note
  parameters:
    note: P3
  states: {}
- name: note_0_0_0_2_0_0
  id: note
  parameters:
    note: P4
  states: {}
- name: qtgui_number_sink_0_2_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_VERT
    gui_hint: menu@1:0,0,1,1
    name: '"Muestras por segundo en T4"'
    type: float
    unit1: MHz
  states: {}
- name: qtgui_number_sink_0_2_0_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_VERT
    gui_hint: menu@2:0,0,1,1
    name: '"Rata de bits en T4"'
    type: float
    unit1: Mbps
  states: {}
- name: qtgui_number_sink_0_2_0_0_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_VERT
    gui_hint: menu@3:0,0,1,1
    name: '"Channel_BW"'
    type: float
    unit1: MHz
  states: {}
- name: qtgui_time_sink_x_0_1_1
  id: qtgui_time_sink_x
  parameters:
    gui_hint: menu@5:1,0,1,1
    label1: BW=Fmax
    label2: BW=W
    marker1: '0'
    marker2: '1'
    nconnections: '2'
    size: '30'
    srate: Rb
    stemplot: 'True'
    type: float
    width1: '2'
    width2: '2'
    ylabel: ''
    ymax: '1.5'
    ymin: '-1.5'
  states: {}
- name: vs_0
  id: virtual_sink
  parameters:
    stream_id: T4
  states: {}
- name: vs_0_0
  id: virtual_sink
  parameters:
    stream_id: R4
  states: {}
- name: vs_0_0_0
  id: virtual_sink
  parameters:
    stream_id: R4_m
  states: {}
- name: vs_0_0_0_0
  id: virtual_sink
  parameters:
    stream_id: R3_m
  states: {}
- name: vs_0_0_1
  id: virtual_sink
  parameters:
    stream_id: R3
  states: {}
- name: vs_0_2
  id: virtual_sink
  parameters:
    stream_id: T3
  states: {}
- name: vso_0_1_0
  id: virtual_source
  parameters:
    stream_id: R4
  states: {}
- name: vso_0_1_0_0
  id: virtual_source
  parameters:
    stream_id: T4
  states: {}
- name: vso_0_1_0_0_0
  id: virtual_source
  parameters:
    stream_id: R3
  states: {}
- name: wform
  id: epy_module
  parameters:
    source_code: |
      import math
      import numpy
      #######################################################
      ##        Hecho por Homero Ortega Boada              ##
      ##        comdiguis@saber.uis.edu.co                 ##
      ##     Universidad Industrial de Santander           ##
      #######################################################

      #######################################################
      ##               Forma rectangular                   ##
      #######################################################                       
      def rect(Sps):
          return Sps*[1.,]

      #######################################################
      ##               Forma de Nyquist                    ##
      #######################################################                       
      def nyq(Sps,ntaps):
          n=numpy.linspace(-int(ntaps/2), int(ntaps/2-1),ntaps)
          h=numpy.sinc(n/Sps)
      #    return h/numpy.amax(h)
          return h
      #######################################################
      ##               Forma Coseno Alzado                 ##
      #######################################################                       
      def rcos(Sps,ntaps,beta):
          if beta==0:
              h=nyq(Sps,ntaps)
          else:
              h=ntaps*[0,]
              for n in range(ntaps):
                  k=n-ntaps/2. # esto es para que h[n] quede centrada en la mitad del vector
                  if abs(k)==Sps/(2.*beta):
                      h[n]=numpy.sinc(1./(2.*beta))*math.pi/4.
                  else:
                      h[n]=numpy.sinc(k/Sps)*math.cos(beta*k*math.pi/Sps)/(1.-(2.*beta*k/Sps)**2)                
          Amp=numpy.amax(h)
          return h/Amp
      #######################################################
      ##            Forma Raiz de Coseno Alzado            ##
      #######################################################                       

      def rrcos(Sps,ntaps,beta):
          if beta==0:
              h=nyq(Sps,ntaps)
          else:
              h=ntaps*[0,]
              beta4=4.*beta
              for n in range(ntaps):
                  k=n-ntaps/2. # esto es para que h[n] quede centrada en la mitad del vector
                  if k==0:
                      h[n]=1+beta*(4./math.pi-1.)
                  elif abs(k)==Sps/beta4:
                      ha=(1.+2./math.pi)*math.sin(math.pi/beta4)
                      hb=(1.-2./math.pi)*math.cos(math.pi/beta4)
                      h[n]=(ha+hb)*beta/math.sqrt(2.)
                  else:
                      ks=k/Sps
                      kspi=math.pi*ks
                      Num=math.sin(kspi*(1-beta))+beta4*ks*math.cos(kspi*(1+beta))
                      Den=kspi*(1.-(beta4*ks)**2)
                      h[n]=Num/Den                
          Amp=numpy.amax(h)
          return h/Amp
  states: {}

connections:
- [E3TRadio_bipolar_decisor_ff_0, '0', blocks_null_sink_0, '0']
- [E3TRadio_bipolar_decisor_ff_0, '0', vs_0_0_1, '0']
- [E3TRadio_bipolar_decisor_ff_0_0, '0', qtgui_time_sink_x_0_1_1, '1']
- [E3TRadio_bipolar_decisor_ff_0_0, '0', vs_0_0_0_0, '0']
- [E3TRadio_diezma_ff_0, '0', E3TRadio_bipolar_decisor_ff_0, '0']
- [E3TRadio_diezma_ff_0_0, '0', E3TRadio_bipolar_decisor_ff_0_0, '0']
- [analog_const_source_x_0_2_0, '0', qtgui_number_sink_0_2_0, '0']
- [analog_const_source_x_0_2_0_0, '0', qtgui_number_sink_0_2_0_0, '0']
- [analog_const_source_x_0_2_0_0_0, '0', qtgui_number_sink_0_2_0_0_0, '0']
- [b_Canal_AWGN_ff_0, '0', E3TRadio_diezma_ff_0, '0']
- [b_Canal_AWGN_ff_0, '0', vs_0_0, '0']
- [b_Canal_AWGN_ff_0_0, '0', E3TRadio_diezma_ff_0_0, '0']
- [b_Canal_AWGN_ff_0_0, '0', b_EYE_Timing_f_0, '0']
- [b_Canal_AWGN_ff_0_0, '0', b_eye_diagram_f_0, '0']
- [b_Canal_AWGN_ff_0_0, '0', vs_0_0_0, '0']
- [b_binary_bipolar_source1_f_0, '0', interp_fir_filter_xxx_0, '0']
- [b_binary_bipolar_source1_f_0, '0', vs_0_2, '0']
- [blocks_delay_0, '0', qtgui_time_sink_x_0_1_1, '0']
- [interp_fir_filter_xxx_0, '0', b_Canal_AWGN_ff_0, '0']
- [interp_fir_filter_xxx_0, '0', vs_0, '0']
- [vso_0_1_0, '0', b_PSD_0_0_0, '0']
- [vso_0_1_0_0, '0', b_Canal_AWGN_ff_0_0, '0']
- [vso_0_1_0_0, '0', b_Eye_Diagram_simple_f_0, '0']
- [vso_0_1_0_0_0, '0', blocks_delay_0, '0']

metadata:
  file_format: 1
