options:
  parameters:
    generate_options: qt_gui
    id: top_block
    output_language: python
    run: run_stop
  states: {}

blocks:
- name: Ab
  id: variable
  parameters:
    value: '1.'
  states: {}
- name: B
  id: variable
  parameters:
    value: 2*BW
  states: {}
- name: BW
  id: variable
  parameters:
    value: '100000'
  states: {}
- name: Channel_BW
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,0,1,1
    label: Channel_BW
    orient: Qt.Horizontal
    start: '0.'
    step: (samp_rate/2)/100.
    stop: samp_rate/2.
    value: samp_rate/2.
  states: {}
- name: Fresol
  id: variable
  parameters:
    value: B/N
  states: {}
- name: N
  id: variable
  parameters:
    value: '1024'
  states: {}
- name: No_dB
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,1,1,1
    label: No (dB)
    orient: Qt.Horizontal
    start: '-300'
    step: 300/100.
    stop: '0'
    value: '-60'
  states: {}
- name: Rb
  id: variable
  parameters:
    value: 2*W
  states: {}
- name: Retardo_T3
  id: variable_qtgui_range
  parameters:
    gui_hint: menu@4:0,1,1,1
    label: Delay to T3
    orient: Qt.Horizontal
    rangeType: int
    start: '0'
    step: '1'
    stop: len(h)*Sps
    value: '0'
  states: {}
- name: Retardo_T4
  id: variable_qtgui_range
  parameters:
    gui_hint: menu@4:0,0,1,1
    label: Delay to T4
    orient: Qt.Horizontal
    rangeType: int
    start: '0'
    step: '1'
    stop: len(h)*Sps
    value: '0'
  states: {}
- name: Retardo_Timing
  id: variable_qtgui_range
  parameters:
    gui_hint: menu@0:0,0,1,1
    label: Timing (M)
    orient: Qt.Horizontal
    rangeType: int
    start: '0'
    step: '1'
    stop: Sps-1
    value: int(Sps/2)
  states: {}
- name: Retardo_bits
  id: variable_qtgui_range
  parameters:
    gui_hint: menu@1:0,0,1,1
    label: Delay transmited signal to match with the received signal
    orient: Qt.Horizontal
    rangeType: int
    start: '0'
    step: '1'
    stop: Sps*10
    value: Retardo_Timing+1
  states: {}
- name: Retardo_ojo
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,1,1,1
    label: Center the Eye by a delay
    orient: Qt.Horizontal
    rangeType: int
    start: '0'
    step: '1'
    stop: Sps*2
    value: int(Sps/2)
  states: {}
- name: Rolloff
  id: variable
  parameters:
    value: '0.5'
  states: {}
- name: SPAN
  id: variable
  parameters:
    value: samp_rate/2
  states: {}
- name: Sps
  id: variable
  parameters:
    value: '4'
  states: {}
- name: W
  id: variable
  parameters:
    value: BW/(1+Rolloff)
  states: {}
- name: h
  id: variable
  parameters:
    value: wform.rcos(Sps,ntaps,Rolloff)
  states: {}
- name: ntaps
  id: variable
  parameters:
    value: '32'
  states: {}
- name: run_stop
  id: variable_qtgui_check_box
  parameters:
    'false': 'False'
    gui_hint: 0,0,1,1
    label: Pause
    'true': 'True'
    type: int
    value: 'True'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: Rb*Sps
  states: {}
- name: E3TRadio_decisor_fb_0
  id: E3TRadio_decisor_fb
  parameters:
    Umbral: '0.'
  states: {}
- name: E3TRadio_diezma_ff_0
  id: E3TRadio_diezma_ff
  parameters:
    M: Retardo_Timing
    N: Sps
  states: {}
- name: E3TRadio_unipolar_to_bipolar_ff_0
  id: E3TRadio_unipolar_to_bipolar_ff
  parameters:
    Amp: '1.'
  states: {}
- name: b_Canal_AWGN_ff_0
  id: b_Canal_AWGN_ff
  parameters:
    BW: Channel_BW
    Ch_NodB: No_dB
    Ch_Toffset: '0'
    samp_rate: samp_rate
  states: {}
- name: b_EYE_Timing_f_0
  id: b_EYE_Timing_f
  parameters:
    AlphaLineas: '0.5'
    Delay: Retardo_ojo
    GrosorLineas: '20'
    N_eyes: '2'
    Retardo_Timing: Retardo_Timing
    Samprate: samp_rate
    Sps: Sps
    Title: '"Eye Diagram and Timing"'
    Ymax: '2'
    Ymin: '-2'
    gui_hint: menu@0:1,0,1,1
  states: {}
- name: b_binary_bipolar_source_f_0
  id: b_binary_bipolar_source_f
  parameters:
    Am: '1.'
    Spb: '1'
  states: {}
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '1.'
    type: float
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: interp_fir_filter_xxx_0
  id: interp_fir_filter_xxx
  parameters:
    interp: Sps
    taps: h
    type: fff
  states: {}
- name: menu
  id: qtgui_tab_widget
  parameters:
    gui_hint: 2,0,1,2
    label0: Eye Diagramm
    label1: T4 versus R4 in time
    label2: PSD
    label3: T3 versus R3
    label4: T4 versus T3 in time
    num_tabs: '5'
  states: {}
- name: note_1
  id: note
  parameters:
    note: Datos entrada
  states: {}
- name: note_1_0
  id: note
  parameters:
    note: P4
  states: {}
- name: note_1_0_0
  id: note
  parameters:
    note: P5
  states: {}
- name: note_1_0_0_0
  id: note
  parameters:
    note: P6
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    gui_hint: menu@3:0,0,1,1
    label1: Transmitted signal
    marker1: '0'
    size: 10*Sps
    srate: samp_rate
    type: float
    width1: '4'
    ymax: '1.5'
    ymin: '-1.5'
  states: {}
- name: qtgui_time_sink_x_0_0_0
  id: qtgui_time_sink_x
  parameters:
    gui_hint: menu@3:1,0,1,1
    label1: Received Signal
    size: 10*Sps
    srate: samp_rate
    type: float
    width1: '4'
    ymax: '1.5'
    ymin: '-1.5'
  states: {}
- name: vs_0
  id: virtual_sink
  parameters:
    stream_id: T3
  states: {}
- name: vs_0_0
  id: virtual_sink
  parameters:
    stream_id: R3
  states: {}
- name: vs_0_0_1
  id: virtual_sink
  parameters:
    stream_id: R4
  states: {}
- name: vs_0_2
  id: virtual_sink
  parameters:
    stream_id: T4
  states: {}
- name: vso_0_1_0_0
  id: virtual_source
  parameters:
    stream_id: R3
  states: {}
- name: vso_0_1_0_0_0_0_0
  id: virtual_source
  parameters:
    stream_id: R3
  states: {}
- name: vso_0_1_0_0_0_1
  id: virtual_source
  parameters:
    stream_id: T3
  states: {}
- name: wform
  id: epy_module
  parameters:
    source_code: |
      import math
      import numpy
      #######################################################
      ##        Hecho por Homero Ortega Boada              ##
      ##        comdiguis@saber.uis.edu.co                 ##
      ##     Universidad Industrial de Santander           ##
      #######################################################

      #######################################################
      ##               Forma rectangular                   ##
      #######################################################                       
      def rect(Sps):
          return Sps*[1.,]

      #######################################################
      ##               Forma de Nyquist                    ##
      #######################################################                       
      def nyq(Sps,ntaps):
          n=numpy.linspace(-int(ntaps/2), int(ntaps/2-1),ntaps)
          h=numpy.sinc(n/Sps)
      #    return h/numpy.amax(h)
          return h
      #######################################################
      ##               Forma Coseno Alzado                 ##
      #######################################################                       
      def rcos(Sps,ntaps,beta):
          if beta==0:
              h=nyq(Sps,ntaps)
          else:
              h=ntaps*[0,]
              for n in range(ntaps):
                  k=n-ntaps/2. # esto es para que h[n] quede centrada en la mitad del vector
                  if abs(k)==Sps/(2.*beta):
                      h[n]=numpy.sinc(1./(2.*beta))*math.pi/4.
                  else:
                      h[n]=numpy.sinc(k/Sps)*math.cos(beta*k*math.pi/Sps)/(1.-(2.*beta*k/Sps)**2)                
          Amp=numpy.amax(h)
          return h/Amp
      #######################################################
      ##            Forma Raiz de Coseno Alzado            ##
      #######################################################                       

      def rrcos(Sps,ntaps,beta):
          if beta==0:
              h=nyq(Sps,ntaps)
          else:
              h=ntaps*[0,]
              beta4=4.*beta
              for n in range(ntaps):
                  k=n-ntaps/2. # esto es para que h[n] quede centrada en la mitad del vector
                  if k==0:
                      h[n]=1+beta*(4./math.pi-1.)
                  elif abs(k)==Sps/beta4:
                      ha=(1.+2./math.pi)*math.sin(math.pi/beta4)
                      hb=(1.-2./math.pi)*math.cos(math.pi/beta4)
                      h[n]=(ha+hb)*beta/math.sqrt(2.)
                  else:
                      ks=k/Sps
                      kspi=math.pi*ks
                      Num=math.sin(kspi*(1-beta))+beta4*ks*math.cos(kspi*(1+beta))
                      Den=kspi*(1.-(beta4*ks)**2)
                      h[n]=Num/Den                
          Amp=numpy.amax(h)
          return h/Amp
  states: {}

connections:
- [E3TRadio_decisor_fb_0, '0', blocks_char_to_float_0, '0']
- [E3TRadio_diezma_ff_0, '0', E3TRadio_decisor_fb_0, '0']
- [E3TRadio_unipolar_to_bipolar_ff_0, '0', blocks_null_sink_0, '0']
- [E3TRadio_unipolar_to_bipolar_ff_0, '0', vs_0_0_1, '0']
- [b_Canal_AWGN_ff_0, '0', blocks_multiply_const_vxx_0, '0']
- [b_binary_bipolar_source_f_0, '0', interp_fir_filter_xxx_0, '0']
- [b_binary_bipolar_source_f_0, '0', vs_0_2, '0']
- [blocks_char_to_float_0, '0', E3TRadio_unipolar_to_bipolar_ff_0, '0']
- [blocks_multiply_const_vxx_0, '0', E3TRadio_diezma_ff_0, '0']
- [blocks_multiply_const_vxx_0, '0', vs_0_0, '0']
- [interp_fir_filter_xxx_0, '0', b_Canal_AWGN_ff_0, '0']
- [interp_fir_filter_xxx_0, '0', vs_0, '0']
- [vso_0_1_0_0, '0', b_EYE_Timing_f_0, '0']
- [vso_0_1_0_0_0_0_0, '0', qtgui_time_sink_x_0_0_0, '0']
- [vso_0_1_0_0_0_1, '0', qtgui_time_sink_x_0_0, '0']

metadata:
  file_format: 1
