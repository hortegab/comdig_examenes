options:
  parameters:
    author: Marly Gallo
    description: Implementacion de la envolvente compleja
    generate_options: qt_gui
    id: Envolvente_Compleja
    output_language: python
    title: PARCIAL 2
  states: {}

blocks:
- name: A
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,0,1,1
    label: Amplitud
    orient: Qt.Horizontal
    start: '-5'
    step: '0.1'
    stop: '5'
    value: '1'
  states: {}
- name: Fc
  id: variable
  parameters:
    value: '400'
  states: {}
- name: Frec_Sample
  id: variable
  parameters:
    value: '4800'
  states: {}
- name: rbs
  id: variable
  parameters:
    value: '100'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: E3TRadio_acumulador_truncado_ff_0
  id: E3TRadio_acumulador_truncado_ff
  parameters:
    M: '0'
    N: '100'
  states: {}
- name: analog_const_source_x_0
  id: analog_const_source_x
  parameters:
    const: math.pi
    type: float
  states: {}
- name: analog_const_source_x_0_0
  id: analog_const_source_x
  parameters:
    const: A
    type: float
  states: {}
- name: blocks_add_const_vxx_0
  id: blocks_add_const_vxx
  parameters:
    const: '-1'
    type: float
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_complex_to_float_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: (2*math.pi)/100
    type: float
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: float
    vector: (0,1,1,0,1,0)
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self, example_param=1.0):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='Generador_EC',   # will show up in GRC
                  in_sig=[np.float32, np.float32],
                  out_sig=[np.complex64]
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              self.example_param = example_param

          def work(self, input_items, output_items):
              """example: multiply with constant"""
              Fase=input_items[0]
              Amplitud=input_items[1]
              EC=output_items[0]
              EC[:] = Amplitud*np.exp(1.j*Fase)
              return len(EC)
    example_param: '1.0'
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: interp_fir_filter_xxx_0
  id: interp_fir_filter_xxx
  parameters:
    interp: '200'
    taps: '[1]*200'
    type: fff
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: ec
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: ec
  states: {}

connections:
- [E3TRadio_acumulador_truncado_ff_0, '0', blocks_multiply_const_vxx_0, '0']
- [analog_const_source_x_0, '0', blocks_multiply_xx_0, '1']
- [analog_const_source_x_0_0, '0', epy_block_0, '1']
- [blocks_add_const_vxx_0, '0', blocks_multiply_xx_0, '0']
- [blocks_add_xx_0, '0', epy_block_0, '0']
- [blocks_complex_to_float_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_complex_to_float_0, '1', qtgui_time_sink_x_1, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_add_xx_0, '0']
- [blocks_multiply_xx_0, '0', blocks_add_xx_0, '1']
- [blocks_vector_source_x_0, '0', interp_fir_filter_xxx_0, '0']
- [epy_block_0, '0', virtual_sink_0, '0']
- [interp_fir_filter_xxx_0, '0', E3TRadio_acumulador_truncado_ff_0, '0']
- [interp_fir_filter_xxx_0, '0', blocks_add_const_vxx_0, '0']
- [virtual_source_0, '0', blocks_complex_to_float_0, '0']

metadata:
  file_format: 1
