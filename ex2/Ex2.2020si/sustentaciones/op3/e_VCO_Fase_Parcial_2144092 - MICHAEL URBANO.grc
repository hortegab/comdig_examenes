options:
  parameters:
    author: labcomunicaciones2_2020
    generate_options: qt_gui
    id: e_VCO_Fase_Parcialgrc
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: A
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,0,1,1
    label: A
    orient: Qt.Horizontal
    start: '-1.5'
    step: (1.5)/100.
    stop: '1.5'
    value: '1.'
  states: {}
- name: Ar
  id: variable_qtgui_range
  parameters:
    gui_hint: 2,0,1,1
    label: Ruido
    orient: Qt.Horizontal
    start: '0'
    step: (4.)/50.
    stop: '4.'
    value: '0.08'
  states: {}
- name: BpS
  id: variable
  parameters:
    value: int(math.log(M,2))
  states: {}
- name: M
  id: variable
  parameters:
    value: '4'
  states: {}
- name: P
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,1,1,1
    label: Fase
    orient: Qt.Horizontal
    start: '-2.*math.pi'
    step: (4.*math.pi)/360.
    stop: 2.*math.pi
    value: '0.'
  states: {}
- name: Rb
  id: variable
  parameters:
    value: '100'
  states: {}
- name: Rs
  id: variable
  parameters:
    value: Rb/BpS
  states: {}
- name: Sps
  id: variable
  parameters:
    value: 64*BpS
  states: {}
- name: Tupdate
  id: variable
  parameters:
    value: 1./Rb
  states: {}
- name: run_stop
  id: variable_qtgui_check_box
  parameters:
    'false': 'False'
    gui_hint: 0,0,1,1
    label: Inicial/Parar
    'true': 'True'
    type: int
    value: 'True'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: Rs*Sps
  states: {}
- name: E3TRadio_Zero_Order_Hold_0
  id: E3TRadio_Zero_Order_Hold
  parameters:
    k: int(Sps/BpS)
  states: {}
- name: E3TRadio_zero_order_hold2_cc_0
  id: E3TRadio_zero_order_hold2_cc
  parameters:
    k: Sps
  states: {}
- name: analog_const_source_x_0_0_0
  id: analog_const_source_x
  parameters:
    const: A
    type: float
  states: {}
- name: analog_noise_source_x_1
  id: analog_noise_source_x
  parameters:
    amp: Ar
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: complex
  states: {}
- name: analog_random_uniform_source_x_0
  id: analog_random_uniform_source_x
  parameters:
    maximum: '2'
    minimum: '0'
    seed: '0'
    type: byte
  states: {state: disabled}
- name: blocks_add_xx_1
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_char_to_float_1
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_complex_to_float_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: (2*math.pi)/M+P
    type: float
  states: {}
- name: blocks_pack_k_bits_bb_0
  id: blocks_pack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: blocks_packed_to_unpacked_xx_0
  id: blocks_packed_to_unpacked_xx
  parameters:
    bits_per_chunk: BpS
    endianness: gr.GR_MSB_FIRST
    type: byte
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: byte
    vector: (0,1,0,1,0,1,0,1)
  states: {}
- name: e_VCO_fase_fc_0
  id: epy_block
  parameters:
    _source_code: "\nimport numpy as np\nfrom gnuradio import gr\n\n\nclass blk(gr.sync_block):  \n    \"\"\"Done by Homero Ortega Boada. Es un VCO dos entradas: \nin0 para manipular la fase, in1 para manipular la \nmagnitud. En el fondo es el equivalente a un generador\nde una senal exponencial compleja. Sobre la configuracion:\ncada valor de la senal en in0 es interpretada como la fase\ndeseada en radianes. cada valor de in0, es la magnitud deseada\"\"\"\n\n    def __init__(self): \n        gr.sync_block.__init__(self,\n            name='e_VCO_fase_fc',\n            in_sig=[np.float32, np.float32],\n            out_sig=[np.complex64]\n        )\n    def work(self, input_items, output_items):\n        in0=input_items[0]\n        in1=input_items[1]\n        out0=output_items[0]\n        out0[:] = in1*np.exp(1.j*in0)\n        return len(out0)\n"
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    gui_hint: 4,0,1,1
    label1: '''.'''
    name: ''
    size: '8'
    type: complex
    update_time: Tupdate
    width1: '4'
    xmax: '1.5'
    xmin: '-1.5'
    ymax: '1.5'
    ymin: '-1.5'
  states: {state: disabled}
- name: qtgui_const_sink_x_1
  id: qtgui_const_sink_x
  parameters:
    gui_hint: 4,0,1,1
    name: '"CONSTELACION"'
    size: '4000'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    gui_hint: 4,1,1,2
    label1: Re
    label2: Im
    name: '"Senal Modulada. Envolvente Compleja"'
    size: '1024'
    srate: (samp_rate)
    type: complex
    update_time: Tupdate
    width1: '3'
    width2: '3'
    ymax: '1.5'
    ymin: '-1.5'
  states: {state: disabled}
- name: qtgui_time_sink_x_0_0_0
  id: qtgui_time_sink_x
  parameters:
    gui_hint: 3,1,1,1
    label1: '''.'''
    marker1: '0'
    name: '"Nivel de Fase. M-PAM"'
    size: int(1024/Sps)
    srate: (samp_rate)
    stemplot: 'True'
    type: float
    update_time: Tupdate
    width1: '3'
    ylabel: Fase
    ymax: 2*math.pi
    ymin: '-2*math.pi'
    yunit: radianes
  states: {}
- name: qtgui_time_sink_x_0_0_0_0
  id: qtgui_time_sink_x
  parameters:
    gui_hint: 3,0,1,1
    label1: '''.'''
    name: '"Nivel de Amplitud"'
    size: '1024'
    srate: (samp_rate)
    type: float
    update_time: Tupdate
    width1: '3'
    ylabel: Amplitud
    ymax: '1.5'
    ymin: '-1.5'
    yunit: volts
  states: {}
- name: qtgui_time_sink_x_0_0_0_0_0
  id: qtgui_time_sink_x
  parameters:
    gui_hint: 4,1,1,2
    label1: Mensaje
    label2: BPSK parte real
    label3: BPSK parte Imaginaria
    name: '"Comparacion de mensaje y EC"'
    nconnections: '3'
    size: '1024'
    srate: (samp_rate)
    type: float
    update_time: Tupdate
    width1: '3'
    ylabel: Amplitud
    ymax: '1.5'
    ymin: '-1.5'
    yunit: volts
  states: {}
- name: vs
  id: virtual_sink
  parameters:
    stream_id: P1
  states: {}
- name: vs_0_0
  id: virtual_sink
  parameters:
    stream_id: P2a
  states: {}
- name: vs_0_0_0
  id: virtual_sink
  parameters:
    stream_id: P2b
  states: {}
- name: vs_0_0_1
  id: virtual_sink
  parameters:
    stream_id: P2m
  states: {}
- name: vso
  id: virtual_source
  parameters:
    stream_id: P1
  states: {}
- name: vso_0_0
  id: virtual_source
  parameters:
    stream_id: P2a
  states: {}
- name: vso_0_0_0
  id: virtual_source
  parameters:
    stream_id: P2b
  states: {}
- name: vso_0_1
  id: virtual_source
  parameters:
    stream_id: P2m
  states: {}

connections:
- [E3TRadio_Zero_Order_Hold_0, '0', qtgui_time_sink_x_0_0_0_0_0, '0']
- [E3TRadio_zero_order_hold2_cc_0, '0', blocks_add_xx_1, '1']
- [analog_const_source_x_0_0_0, '0', e_VCO_fase_fc_0, '1']
- [analog_const_source_x_0_0_0, '0', vs_0_0_0, '0']
- [analog_noise_source_x_1, '0', blocks_add_xx_1, '0']
- [analog_random_uniform_source_x_0, '0', blocks_char_to_float_1, '0']
- [analog_random_uniform_source_x_0, '0', blocks_pack_k_bits_bb_0, '0']
- [blocks_add_xx_1, '0', blocks_throttle_0, '0']
- [blocks_char_to_float_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_char_to_float_1, '0', vs_0_0_1, '0']
- [blocks_complex_to_float_0, '0', qtgui_time_sink_x_0_0_0_0_0, '1']
- [blocks_complex_to_float_0, '1', qtgui_time_sink_x_0_0_0_0_0, '2']
- [blocks_multiply_const_vxx_0, '0', e_VCO_fase_fc_0, '0']
- [blocks_multiply_const_vxx_0, '0', vs_0_0, '0']
- [blocks_pack_k_bits_bb_0, '0', blocks_packed_to_unpacked_xx_0, '0']
- [blocks_packed_to_unpacked_xx_0, '0', blocks_char_to_float_0, '0']
- [blocks_throttle_0, '0', vs, '0']
- [blocks_vector_source_x_0, '0', blocks_char_to_float_1, '0']
- [blocks_vector_source_x_0, '0', blocks_pack_k_bits_bb_0, '0']
- [e_VCO_fase_fc_0, '0', E3TRadio_zero_order_hold2_cc_0, '0']
- [vso, '0', blocks_complex_to_float_0, '0']
- [vso, '0', qtgui_const_sink_x_0, '0']
- [vso, '0', qtgui_const_sink_x_1, '0']
- [vso, '0', qtgui_time_sink_x_0, '0']
- [vso_0_0, '0', qtgui_time_sink_x_0_0_0, '0']
- [vso_0_0_0, '0', qtgui_time_sink_x_0_0_0_0, '0']
- [vso_0_1, '0', E3TRadio_Zero_Order_Hold_0, '0']

metadata:
  file_format: 1
