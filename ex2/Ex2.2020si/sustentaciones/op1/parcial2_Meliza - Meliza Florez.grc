options:
  parameters:
    generate_options: qt_gui
    id: top_block
    output_language: python
    run: run_stop
  states: {}

blocks:
- name: A
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,0,1,1
    label: A
    orient: Qt.Horizontal
    start: '-1.5'
    step: (1.5)/100.
    stop: '1.5'
    value: '1.'
  states: {}
- name: P
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,1,1,1
    label: Fase
    orient: Qt.Horizontal
    start: '-2.*math.pi'
    step: (4.*math.pi)/360.
    stop: 2.*math.pi
    value: '0.'
  states: {}
- name: Rb
  id: variable
  parameters:
    value: '100'
  states: {}
- name: Rs
  id: variable
  parameters:
    value: fc/2
  states: {}
- name: Tupdate
  id: variable
  parameters:
    value: 1./Rb
  states: {}
- name: fc
  id: variable
  parameters:
    value: '200'
  states: {}
- name: fs
  id: variable
  parameters:
    value: 3.2e3
  states: {}
- name: run_stop
  id: variable_qtgui_check_box
  parameters:
    'false': 'False'
    gui_hint: 0,0,1,1
    label: Inicial/Parar
    'true': 'True'
    type: int
    value: 'True'
  states: {}
- name: sps
  id: variable
  parameters:
    value: fs/Rs
  states: {}
- name: analog_const_source_x_0_0_0
  id: analog_const_source_x
  parameters:
    const: A
    type: float
  states: {}
- name: b_binary_bipolar_source_f_0
  id: b_binary_bipolar_source_f
  parameters:
    Am: '1.'
    Spb: '1'
  states: {}
- name: blocks_add_const_vxx_0
  id: blocks_add_const_vxx
  parameters:
    const: '-1'
    type: float
  states: {}
- name: blocks_add_const_vxx_0_0
  id: blocks_add_const_vxx
  parameters:
    const: +(2*math.pi)
    type: float
  states: {}
- name: blocks_complex_to_float_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '-math.pi/2+P'
    type: float
  states: {}
- name: e_VCO_fase_fc_0
  id: epy_block
  parameters:
    _source_code: "\nimport numpy as np\nfrom gnuradio import gr\n\n\nclass blk(gr.sync_block):  \n    \"\"\"Done by Homero Ortega Boada. Es un VCO dos entradas: \nin0 para manipular la fase, in1 para manipular la \nmagnitud. En el fondo es el equivalente a un generador\nde una senal exponencial compleja. Sobre la configuracion:\ncada valor de la senal en in0 es interpretada como la fase\ndeseada en radianes. cada valor de in0, es la magnitud deseada\"\"\"\n\n    def __init__(self): \n        gr.sync_block.__init__(self,\n            name='e_VCO_fase_fc',\n            in_sig=[np.float32, np.float32],\n            out_sig=[np.complex64]\n        )\n    def work(self, input_items, output_items):\n        in0=input_items[0]\n        in1=input_items[1]\n        out0=output_items[0]\n        out0[:] = in1*np.exp(1.j*in0)\n        return len(out0)\n"
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: qtgui_time_sink_x_0_0_0
  id: qtgui_time_sink_x
  parameters:
    gui_hint: 3,1,1,1
    label1: '''.'''
    marker1: '0'
    name: '"Nivel de Fase"'
    size: int(1024/sps)
    srate: fs
    stemplot: 'True'
    type: float
    update_time: Tupdate
    width1: '3'
    ylabel: Fase
    ymax: 2*math.pi
    ymin: '-2*math.pi'
    yunit: radianes
  states: {}
- name: qtgui_time_sink_x_0_0_0_0
  id: qtgui_time_sink_x
  parameters:
    gui_hint: 3,0,1,1
    label1: '''.'''
    name: '"Nivel de Amplitud"'
    size: '1024'
    srate: fs
    type: float
    update_time: Tupdate
    width1: '3'
    ylabel: Amplitud
    ymax: '1.5'
    ymin: '-1.5'
    yunit: volts
  states: {}
- name: qtgui_time_sink_x_0_0_0_0_0
  id: qtgui_time_sink_x
  parameters:
    color1: black
    gui_hint: 3,2,1,1
    label1: Mensaje
    label2: BPSK parte real
    label3: BPSK parte Imaginaria
    name: '"Comparacion de mensaje y EC"'
    nconnections: '3'
    size: '1024'
    srate: fs
    type: float
    update_time: Tupdate
    width1: '3'
    ylabel: Amplitud
    ymax: '1.5'
    ymin: '-1.5'
    yunit: volts
  states: {}
- name: vs
  id: virtual_sink
  parameters:
    stream_id: P1
  states: {}
- name: vs_0_0
  id: virtual_sink
  parameters:
    stream_id: P2a
  states: {}
- name: vs_0_0_0
  id: virtual_sink
  parameters:
    stream_id: P2b
  states: {}
- name: vs_0_0_1
  id: virtual_sink
  parameters:
    stream_id: P2m
  states: {}
- name: vso
  id: virtual_source
  parameters:
    stream_id: P1
  states: {}
- name: vso_0_0
  id: virtual_source
  parameters:
    stream_id: P2a
  states: {}
- name: vso_0_0_0
  id: virtual_source
  parameters:
    stream_id: P2b
  states: {}
- name: vso_0_1
  id: virtual_source
  parameters:
    stream_id: P2m
  states: {}

connections:
- [analog_const_source_x_0_0_0, '0', e_VCO_fase_fc_0, '1']
- [analog_const_source_x_0_0_0, '0', vs_0_0_0, '0']
- [b_binary_bipolar_source_f_0, '0', blocks_add_const_vxx_0, '0']
- [b_binary_bipolar_source_f_0, '0', vs_0_0_1, '0']
- [blocks_add_const_vxx_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_add_const_vxx_0_0, '0', e_VCO_fase_fc_0, '0']
- [blocks_add_const_vxx_0_0, '0', vs_0_0, '0']
- [blocks_complex_to_float_0, '0', qtgui_time_sink_x_0_0_0_0_0, '1']
- [blocks_complex_to_float_0, '1', qtgui_time_sink_x_0_0_0_0_0, '2']
- [blocks_multiply_const_vxx_0, '0', blocks_add_const_vxx_0_0, '0']
- [e_VCO_fase_fc_0, '0', vs, '0']
- [vso, '0', blocks_complex_to_float_0, '0']
- [vso_0_0, '0', qtgui_time_sink_x_0_0_0, '0']
- [vso_0_0_0, '0', qtgui_time_sink_x_0_0_0_0, '0']
- [vso_0_1, '0', qtgui_time_sink_x_0_0_0_0_0, '0']

metadata:
  file_format: 1
