options:
  parameters:
    author: Example
    category: Custom
    description: Adjust the noise and constellation... see what happens!
    generate_options: qt_gui
    id: ber_simulation
    output_language: python
    run: run_stop
    title: BER Simulation
  states: {}

blocks:
- name: B
  id: variable
  parameters:
    value: 2*BW
  states: {}
- name: BW
  id: variable
  parameters:
    value: W*(1+rolloff)
  states: {}
- name: Constelacion
  id: variable
  parameters:
    value: (digital.constellation_bpsk(), digital.constellation_qpsk(), digital.constellation_8psk(), digital.qam.qam_constellation(16))
  states: {state: disabled}
- name: Constelacion
  id: variable
  parameters:
    value: '[(raiz2 + raiz2*1j),  (-raiz2 + raiz2*1j), (-raiz2 - raiz2*1j), (raiz2 - raiz2*1j)]'
  states: {state: disabled}
- name: Constelacion
  id: variable
  parameters:
    value: digital.constellation_8psk().points()
  states: {state: disabled}
- name: Constelacion
  id: variable
  parameters:
    value: digital.constellation_qpsk().points()
  states: {}
- name: EbN0
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,3,1,1
    label: Eb / N0 (dB)
    orient: Qt.Horizontal
    start: '-30'
    step: '1'
    stop: '200'
    value: '14.'
  states: {state: disabled}
- name: M
  id: variable
  parameters:
    value: len(Constelacion)
  states: {}
- name: Rb
  id: variable
  parameters:
    value: Rs*bps
  states: {}
- name: Retardo_Timing
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,1,1,1
    label: Timing
    orient: Qt.Horizontal
    rangeType: int
    start: '0'
    step: '1'
    stop: Sps-1
    value: '0'
  states: {}
- name: Retardo_propag
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,2,1,1
    label: Propagation delay
    orient: Qt.Horizontal
    rangeType: int
    start: '0'
    step: '1'
    stop: Sps*200
    value: int(ntaps/Sps)+1
  states: {}
- name: Retardo_propag
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,2,1,1
    label: Propagation delay
    orient: Qt.Horizontal
    rangeType: int
    start: '0'
    step: '1'
    stop: Sps*200
    value: '0'
  states: {state: disabled}
- name: Rs
  id: variable
  parameters:
    value: samp_rate/Sps
  states: {}
- name: Sps
  id: variable
  parameters:
    value: '8'
  states: {}
- name: W
  id: variable
  parameters:
    value: Rs/2
  states: {}
- name: bits_retardo
  id: variable
  parameters:
    value: Retardo_propag*bps
  states: {}
- name: bps
  id: variable
  parameters:
    value: int(math.log(M,2))
  states: {}
- name: h_rect
  id: variable
  parameters:
    value: wform.rect(Sps,ntaps)
  states: {}
- name: h_rrc
  id: variable
  parameters:
    value: wform.rrcos(Sps,ntaps,rolloff)
  states: {}
- name: ntaps
  id: variable
  parameters:
    value: Sps*16
  states: {}
- name: raiz2
  id: variable
  parameters:
    value: 2**(1/2)
  states: {}
- name: rolloff
  id: variable
  parameters:
    value: '0.35'
  states: {}
- name: run_stop
  id: variable_qtgui_check_box
  parameters:
    'false': 'False'
    gui_hint: 0,0,1,1
    label: Pause
    'true': 'True'
    type: int
    value: 'True'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 100e3
  states: {}
- name: E3TRadio_diezmador_cc_0
  id: E3TRadio_diezmador_cc
  parameters:
    paso: Sps
  states: {}
- name: analog_random_source_x
  id: analog_random_source_x
  parameters:
    max: M
    min: '0'
    num_samps: '10000000'
    repeat: 'True'
    type: byte
  states: {state: disabled}
- name: b_Eye_Timing_c_0
  id: b_Eye_Timing_c
  parameters:
    AlphaLineas: '0.5'
    GrosorLineas: '20'
    N_eyes: '2'
    Retardo_Timing: Retardo_Timing
    Samprate: samp_rate
    Sps: Sps
    Title: '"Eye Diagram and Timing"'
    Ymax: '2'
    Ymin: '-2'
    gui_hint: menu@1:1,0,1,1
  states: {}
- name: b_PSD_c_0
  id: b_PSD_c
  parameters:
    Ensayos: '1000000'
    Fc: '0'
    N: '1024'
    Ymax: '1e-5'
    gui_hint: menu@4:2,0,1,1
    samp_rate_audio: samp_rate
  states: {}
- name: b_PSD_c_0_0
  id: b_PSD_c
  parameters:
    Ensayos: '1000000'
    Fc: '0'
    N: '1024'
    Ymax: '1e-5'
    gui_hint: menu@4:1,0,1,1
    samp_rate_audio: samp_rate
  states: {}
- name: b_demod_constelacion_cb_0
  id: b_demod_constelacion_cb
  parameters:
    Constelacion: Constelacion
  states: {}
- name: b_mod_constelacion_cb_0
  id: b_mod_constelacion_cb
  parameters:
    Constelacion: Constelacion
  states: {}
- name: blocks_char_to_float_0_0_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_char_to_float_0_0_0_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_char_to_float_0_1
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_char_to_float_0_1_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: '0'
    type: byte
  states: {}
- name: blocks_delay_0_0
  id: blocks_delay
  parameters:
    delay: Sps-Retardo_Timing
    type: complex
  states: {}
- name: blocks_delay_0_1
  id: blocks_delay
  parameters:
    delay: Retardo_propag
    type: byte
  states: {}
- name: blocks_delay_0_1_0
  id: blocks_delay
  parameters:
    delay: Retardo_propag
    type: byte
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /home/hortegab/MisGits/comdig_examenes/ex2/Ex2.2020ai/recibido.txt
    type: byte
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/hortegab/MisGits/comdig_examenes/ex2/Ex2.2020ai/enviado.txt
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: 1./Sps
    type: complex
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: byte
  states: {state: disabled}
- name: blocks_pack_k_bits_bb_0
  id: blocks_pack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: blocks_packed_to_unpacked_xx_0
  id: blocks_packed_to_unpacked_xx
  parameters:
    bits_per_chunk: bps
    endianness: gr.GR_LSB_FIRST
    type: byte
  states: {}
- name: blocks_unpack_k_bits_bb_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: blocks_unpack_k_bits_bb_0_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: bps
  states: {}
- name: blocks_unpacked_to_packed_xx_0
  id: blocks_unpacked_to_packed_xx
  parameters:
    bits_per_chunk: bps
    endianness: gr.GR_MSB_FIRST
    type: byte
  states: {}
- name: import
  id: import
  parameters:
    imports: import math
  states: {}
- name: import_0
  id: import
  parameters:
    imports: from gnuradio import digital
  states: {}
- name: interp_fir_filter_xxx_0_0_0
  id: interp_fir_filter_xxx
  parameters:
    interp: Sps
    taps: h_rrc
    type: ccc
  states: {}
- name: interp_fir_filter_xxx_0_0_0_0
  id: interp_fir_filter_xxx
  parameters:
    interp: '1'
    taps: h_rrc
    type: ccc
  states: {}
- name: menu
  id: qtgui_tab_widget
  parameters:
    gui_hint: 2,0,1,4
    label0: Constelation Timing
    label1: Eye Timing
    label2: M-PAM
    label3: EC
    label4: PSD
    label5: Constelation Channel
    label6: PCM
    num_tabs: '7'
  states: {}
- name: note_0
  id: note
  parameters:
    note: M-PAM LAYER
  states: {}
- name: note_0_0
  id: note
  parameters:
    note: ADAPTATION LAYER
  states: {}
- name: note_0_0_0_1
  id: note
  parameters:
    note: Modulation
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    gui_hint: menu@0:1,0,1,1
    label1: T4
    label2: R4
    nconnections: '2'
    size: '1024'
    type: complex
  states: {}
- name: qtgui_const_sink_x_0_0
  id: qtgui_const_sink_x
  parameters:
    gui_hint: menu@5:1,0,1,1
    label1: T1
    label2: R1a
    marker1: '-1'
    marker2: '-1'
    nconnections: '2'
    size: '1024'
    style1: '1'
    style2: '1'
    type: complex
    width1: '3'
    width2: '3'
  states: {}
- name: qtgui_time_sink_x_0_0_0
  id: qtgui_time_sink_x
  parameters:
    gui_hint: menu@3:1,0,1,1
    label1: T1 (Re)
    label2: T1 (Im)
    label3: R1a (Re)
    label4: R1a (Im)
    nconnections: '2'
    size: 20*Sps
    srate: samp_rate
    type: complex
    width1: '3'
    width2: '3'
    width3: '3'
    width4: '3'
    ymax: '3'
    ymin: '-3'
  states: {}
- name: qtgui_time_sink_x_0_1
  id: qtgui_time_sink_x
  parameters:
    gui_hint: menu@2:1,0,1,1
    label1: MPAM (T5)
    label2: MPAM (R5)
    nconnections: '2'
    size: '60'
    srate: Rs
    type: float
    width1: '2'
    width2: '2'
    ymax: M
  states: {}
- name: qtgui_time_sink_x_0_1_0
  id: qtgui_time_sink_x
  parameters:
    gui_hint: menu@6:1,0,1,1
    label1: MPAM (T5)
    label2: MPAM (R5)
    nconnections: '2'
    size: '60'
    srate: Rs
    type: float
    width1: '2'
    width2: '2'
    ymax: M
  states: {}
- name: virtual_sink_0_0_0
  id: virtual_sink
  parameters:
    stream_id: T5
  states: {}
- name: virtual_sink_0_0_0_0
  id: virtual_sink
  parameters:
    stream_id: R5
  states: {}
- name: virtual_sink_0_0_0_0_0
  id: virtual_sink
  parameters:
    stream_id: R6
  states: {}
- name: virtual_sink_0_0_0_1
  id: virtual_sink
  parameters:
    stream_id: T6
  states: {}
- name: vs_0_0_1
  id: virtual_sink
  parameters:
    stream_id: R4
  states: {}
- name: vs_0_0_1_0
  id: virtual_sink
  parameters:
    stream_id: R1a
  states: {}
- name: vs_0_2
  id: virtual_sink
  parameters:
    stream_id: T4
  states: {}
- name: vs_0_2_0
  id: virtual_sink
  parameters:
    stream_id: T1
  states: {}
- name: vso_0_1_0_0
  id: virtual_source
  parameters:
    stream_id: R1a
  states: {}
- name: vso_0_1_0_0_0
  id: virtual_source
  parameters:
    stream_id: T4
  states: {}
- name: vso_0_1_0_0_0_0
  id: virtual_source
  parameters:
    stream_id: R4
  states: {}
- name: vso_0_1_0_0_0_0_0
  id: virtual_source
  parameters:
    stream_id: R5
  states: {}
- name: vso_0_1_0_0_0_0_0_0
  id: virtual_source
  parameters:
    stream_id: R6
  states: {}
- name: vso_0_1_0_0_0_0_1
  id: virtual_source
  parameters:
    stream_id: R1a
  states: {}
- name: vso_0_1_0_0_0_1
  id: virtual_source
  parameters:
    stream_id: T5
  states: {}
- name: vso_0_1_0_0_0_1_0
  id: virtual_source
  parameters:
    stream_id: T6
  states: {}
- name: vso_0_1_0_0_0_2
  id: virtual_source
  parameters:
    stream_id: T1
  states: {}
- name: vso_0_1_0_0_1_0_0
  id: virtual_source
  parameters:
    stream_id: R1a
  states: {}
- name: vso_0_1_0_0_1_1
  id: virtual_source
  parameters:
    stream_id: T1
  states: {}
- name: wform
  id: epy_module
  parameters:
    source_code: |
      import math
      import numpy
      #######################################################
      ##        Hecho por Homero Ortega Boada              ##
      ##        comdiguis@saber.uis.edu.co                 ##
      ##     Universidad Industrial de Santander           ##
      #######################################################

      #######################################################
      ##               Forma rectangular                   ##
      #######################################################                       
      def rect(Sps,ntaps):
          h=ntaps*[0,]
          for n in range(Sps):
              k=int(ntaps/2) # esto es para que h[n] quede centrada en la mitad del vector
              h[k-n]=1.
          return h

      #######################################################
      ##               Forma de Nyquist                    ##
      #######################################################                       
      def nyq(Sps,ntaps):
          ntaps_min=-int(ntaps/2)
          ntaps_max=abs(ntaps_min)-1+int(math.ceil(ntaps/2.-abs(ntaps_min)))
          h=ntaps*[0,]
          for n in range(ntaps):
              k=n-ntaps/2. # esto es para que h[n] quede centrada en la mitad del vector
              h[n]=numpy.sinc(k/Sps)
          Amp=numpy.amax(h)
          return h/Amp

      #######################################################
      ##               Forma Coseno Alzado                 ##
      #######################################################                       
      def rcos(Sps,ntaps,beta):
          if beta==0:
              h=nyq(Sps,ntaps)
          else:
              h=ntaps*[0,]
              for n in range(ntaps):
                  k=n-ntaps/2. # esto es para que h[n] quede centrada en la mitad del vector
                  if abs(k)==Sps/(2.*beta):
                      h[n]=numpy.sinc(1./(2.*beta))*math.pi/4.
                  else:
                      h[n]=numpy.sinc(k/Sps)*math.cos(beta*k*math.pi/Sps)/(1.-(2.*beta*k/Sps)**2)                
          Amp=numpy.amax(h)
          return h/Amp

      #######################################################
      ##            Forma Raiz de Coseno Alzado            ##
      #######################################################                       

      def rrcos(Sps,ntaps,beta):
          if beta==0:
              h=nyq(Sps,ntaps)
          else:
              h=ntaps*[0,]
              beta4=4.*beta
              for n in range(ntaps):
                  k=n-ntaps/2. # esto es para que h[n] quede centrada en la mitad del vector
                  if k==0:
                      h[n]=1+beta*(4./math.pi-1.)
                  elif abs(k)==Sps/beta4:
                      ha=(1.+2./math.pi)*math.sin(math.pi/beta4)
                      hb=(1.-2./math.pi)*math.cos(math.pi/beta4)
                      h[n]=(ha+hb)*beta/math.sqrt(2.)
                  else:
                      ks=k/Sps
                      kspi=math.pi*ks
                      Num=math.sin(kspi*(1-beta))+beta4*ks*math.cos(kspi*(1+beta))
                      Den=kspi*(1.-(beta4*ks)**2)
                      h[n]=Num/Den                
          Amp=numpy.amax(h)
          return h/Amp
  states: {}

connections:
- [E3TRadio_diezmador_cc_0, '0', b_demod_constelacion_cb_0, '0']
- [E3TRadio_diezmador_cc_0, '0', vs_0_0_1, '0']
- [analog_random_source_x, '0', b_mod_constelacion_cb_0, '0']
- [analog_random_source_x, '0', virtual_sink_0_0_0, '0']
- [b_demod_constelacion_cb_0, '0', blocks_null_sink_0, '0']
- [b_demod_constelacion_cb_0, '0', blocks_unpacked_to_packed_xx_0, '0']
- [b_demod_constelacion_cb_0, '0', virtual_sink_0_0_0_0, '0']
- [b_mod_constelacion_cb_0, '0', interp_fir_filter_xxx_0_0_0, '0']
- [b_mod_constelacion_cb_0, '0', vs_0_2, '0']
- [blocks_char_to_float_0_0_0, '0', qtgui_time_sink_x_0_1, '1']
- [blocks_char_to_float_0_0_0_0, '0', qtgui_time_sink_x_0_1_0, '1']
- [blocks_char_to_float_0_1, '0', qtgui_time_sink_x_0_1, '0']
- [blocks_char_to_float_0_1_0, '0', qtgui_time_sink_x_0_1_0, '0']
- [blocks_delay_0, '0', blocks_pack_k_bits_bb_0, '0']
- [blocks_delay_0, '0', virtual_sink_0_0_0_0_0, '0']
- [blocks_delay_0_0, '0', E3TRadio_diezmador_cc_0, '0']
- [blocks_delay_0_1, '0', blocks_char_to_float_0_1, '0']
- [blocks_delay_0_1_0, '0', blocks_char_to_float_0_1_0, '0']
- [blocks_file_source_0, '0', blocks_unpack_k_bits_bb_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_delay_0_0, '0']
- [blocks_multiply_const_vxx_0, '0', vs_0_0_1_0, '0']
- [blocks_pack_k_bits_bb_0, '0', blocks_file_sink_0, '0']
- [blocks_packed_to_unpacked_xx_0, '0', b_mod_constelacion_cb_0, '0']
- [blocks_packed_to_unpacked_xx_0, '0', virtual_sink_0_0_0, '0']
- [blocks_unpack_k_bits_bb_0, '0', blocks_packed_to_unpacked_xx_0, '0']
- [blocks_unpack_k_bits_bb_0, '0', virtual_sink_0_0_0_1, '0']
- [blocks_unpack_k_bits_bb_0_0, '0', blocks_delay_0, '0']
- [blocks_unpacked_to_packed_xx_0, '0', blocks_unpack_k_bits_bb_0_0, '0']
- [interp_fir_filter_xxx_0_0_0, '0', interp_fir_filter_xxx_0_0_0_0, '0']
- [interp_fir_filter_xxx_0_0_0, '0', vs_0_2_0, '0']
- [interp_fir_filter_xxx_0_0_0_0, '0', blocks_multiply_const_vxx_0, '0']
- [vso_0_1_0_0, '0', b_Eye_Timing_c_0, '0']
- [vso_0_1_0_0_0, '0', qtgui_const_sink_x_0, '0']
- [vso_0_1_0_0_0_0, '0', qtgui_const_sink_x_0, '1']
- [vso_0_1_0_0_0_0_0, '0', blocks_char_to_float_0_0_0, '0']
- [vso_0_1_0_0_0_0_0_0, '0', blocks_char_to_float_0_0_0_0, '0']
- [vso_0_1_0_0_0_0_1, '0', qtgui_const_sink_x_0_0, '1']
- [vso_0_1_0_0_0_1, '0', blocks_delay_0_1, '0']
- [vso_0_1_0_0_0_1_0, '0', blocks_delay_0_1_0, '0']
- [vso_0_1_0_0_0_2, '0', qtgui_const_sink_x_0_0, '0']
- [vso_0_1_0_0_1_0_0, '0', b_PSD_c_0, '0']
- [vso_0_1_0_0_1_0_0, '0', qtgui_time_sink_x_0_0_0, '1']
- [vso_0_1_0_0_1_1, '0', b_PSD_c_0_0, '0']
- [vso_0_1_0_0_1_1, '0', qtgui_time_sink_x_0_0_0, '0']

metadata:
  file_format: 1
