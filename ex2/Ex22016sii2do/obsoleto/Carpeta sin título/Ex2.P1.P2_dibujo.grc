<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.9'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>MPSK</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>run</key><value>run_stop</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>AccumOffset</value></param>
<param><key>value</key><value>0</value></param>
<param><key>gui_hint</key><value>pestana1@0:0,3,1,1</value></param>
<param><key>label</key><value>Offset Accum.</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>Sps-1</value></param>
<param><key>rangeType</key><value>int</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>B</value></param>
<param><key>value</key><value>Fs_uz</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>Constelacion</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>value</key><value>[1.+0.j,   0.707+ 0.707j,   0.+1.j,  -0.707+ 0.707j,  -1.+0.j,  -0.707- 0.707j,  0.-1.j,  0.707- 0.707j]</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>Constelacion</value></param>
<param><key>value</key><value>[1.+0.j,   0.+1.j,   -1.+0.j,  0.-1.j ]</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>Constelacion</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>value</key><value>[.33+.33j, 1+.33j, 1+1.j, .33+1.j,     -.33+.33j, -1+.33j, -1+1.j, -.33+1.j,    -.33-.33j, -1-.33j, -1-1.j, -.33-1.j,     .33-.33j, 1-.33j, 1-1.j, .33-1.j ]</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>DelayDiez</value></param>
<param><key>value</key><value>int(Sps/2)</value></param>
<param><key>gui_hint</key><value>pestana1@0:0,2,1,1</value></param>
<param><key>label</key><value>Retrazo muestreador</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>Sps-1</value></param>
<param><key>rangeType</key><value>int</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>DelayOjo</value></param>
<param><key>value</key><value>0</value></param>
<param><key>gui_hint</key><value>pestana@6:1,0,1,1</value></param>
<param><key>label</key><value>varie aqui el retrazo de la senal para centrar el ojo</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>Sps</value></param>
<param><key>rangeType</key><value>int</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>Fc</value></param>
<param><key>value</key><value>2000000</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>Foffset</value></param>
<param><key>value</key><value>0</value></param>
<param><key>gui_hint</key><value>pestana1@0:0,0,1,1</value></param>
<param><key>label</key><value>Offset de frec.</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>0.01</value></param>
<param><key>stop</key><value>5</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>Fs_cs</value></param>
<param><key>value</key><value>Fs_pu</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>Fs_pu</value></param>
<param><key>value</key><value>samp_rate*Np</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>Fs_uz</value></param>
<param><key>value</key><value>Fs_cs*Sps</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>Kruido</value></param>
<param><key>value</key><value>0.002</value></param>
<param><key>gui_hint</key><value>1,3,1,1</value></param>
<param><key>label</key><value>Nivel del Ruido</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>0.001</value></param>
<param><key>stop</key><value>1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>M</value></param>
<param><key>value</key><value>len(Constelacion)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>Nbsam</value></param>
<param><key>value</key><value>len(Constelacion)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>Nbsym</value></param>
<param><key>value</key><value>int(math.log(len(Constelacion),2))</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>Np</value></param>
<param><key>value</key><value>Nbsam/Nbsym</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>Nq</value></param>
<param><key>value</key><value>256</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>Phioffset</value></param>
<param><key>value</key><value>0</value></param>
<param><key>gui_hint</key><value>pestana1@0:0,1,1,1</value></param>
<param><key>label</key><value>Offset de angulo</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>-3.1415</value></param>
<param><key>step</key><value>0.1</value></param>
<param><key>stop</key><value>3.1415</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>Rb</value></param>
<param><key>value</key><value>Rs*Nbsym</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>Rs</value></param>
<param><key>value</key><value>Fs_uz/Sps</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>Sps</value></param>
<param><key>value</key><value>16</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>Tmax_scope</value></param>
<param><key>value</key><value>128./Rs</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>ntaps</value></param>
<param><key>value</key><value>512</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>rolloff</value></param>
<param><key>value</key><value>0.75</value></param>
</block>
<block>
<key>variable_qtgui_check_box</key>
<param><key>id</key><value>run_stop</value></param>
<param><key>value</key><value>True</value></param>
<param><key>false</key><value>False</value></param>
<param><key>gui_hint</key><value>1,0,1,1</value></param>
<param><key>label</key><value>Inicial/Parar</value></param>
<param><key>true</key><value>True</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>44000</value></param>
</block>
<block>
<key>E3TRadio_usrp2usrp1_cc</key>
<param><key>id</key><value>E3TRadio_usrp2usrp1_cc_0</value></param>
<param><key>Am</key><value>0.8</value></param>
<param><key>BW</key><value>B/2.</value></param>
<param><key>Katt</key><value>10.</value></param>
<param><key>samp_rate</key><value>Fs_uz</value></param>
<param><key>Vruido</key><value>Kruido</value></param>
<param><key>Phoffset</key><value>numpy.pi/3.0</value></param>
<param><key>Foffset</key><value>0.01</value></param>
<param><key>Toffset</key><value>int(Sps*random.random())</value></param>
</block>
<block>
<key>E3TRadio_zero_order_hold2_cc</key>
<param><key>id</key><value>E3TRadio_zero_order_hold2_cc_0</value></param>
<param><key>k</key><value>Sps</value></param>
</block>
<block>
<key>audio_source</key>
<param><key>id</key><value>audio_source_0</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
</block>
<block>
<key>b_accum_cc</key>
<param><key>id</key><value>b_accum_cc_0</value></param>
<param><key>M</key><value>AccumOffset</value></param>
<param><key>N</key><value>Sps</value></param>
</block>
<block>
<key>b_quantizer_fb</key>
<param><key>id</key><value>b_quantizer_fb_0</value></param>
<param><key>ValorPico</key><value>1</value></param>
</block>
<block>
<key>b_sampler_cc</key>
<param><key>id</key><value>b_sampler_cc_0</value></param>
<param><key>DelayDiez</key><value>DelayDiez</value></param>
<param><key>Sps</key><value>Sps</value></param>
</block>
<block>
<key>b_tunner</key>
<param><key>id</key><value>b_tunner_0</value></param>
<param><key>fdesv</key><value>-Foffset</value></param>
<param><key>phi</key><value>Phioffset</value></param>
<param><key>samp_rate</key><value>Fs_uz</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_0</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_0_0</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_packed_to_unpacked_xx</key>
<param><key>id</key><value>blocks_packed_to_unpacked_xx_0</value></param>
<param><key>bits_per_chunk</key><value>Nbsym</value></param>
<param><key>endianness</key><value>gr.GR_MSB_FIRST</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0</value></param>
<param><key>samples_per_second</key><value>Fs_uz</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>digital_chunks_to_symbols_xx</key>
<param><key>id</key><value>digital_chunks_to_symbols_xx_0</value></param>
<param><key>dimension</key><value>1</value></param>
<param><key>in_type</key><value>byte</value></param>
<param><key>out_type</key><value>complex</value></param>
<param><key>symbol_table</key><value>Constelacion</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>import math</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0_0</value></param>
<param><key>import</key><value>import numpy</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0_0_0</value></param>
<param><key>import</key><value>import random</value></param>
</block>
<connection><source_block_id>E3TRadio_usrp2usrp1_cc_0</source_block_id><sink_block_id>b_tunner_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>E3TRadio_zero_order_hold2_cc_0</source_block_id><sink_block_id>blocks_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>audio_source_0</source_block_id><sink_block_id>b_quantizer_fb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>b_accum_cc_0</source_block_id><sink_block_id>b_sampler_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>b_quantizer_fb_0</source_block_id><sink_block_id>blocks_packed_to_unpacked_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>b_sampler_cc_0</source_block_id><sink_block_id>blocks_null_sink_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>b_sampler_cc_0</source_block_id><sink_block_id>blocks_null_sink_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>b_tunner_0</source_block_id><sink_block_id>b_accum_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_packed_to_unpacked_xx_0</source_block_id><sink_block_id>digital_chunks_to_symbols_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>E3TRadio_usrp2usrp1_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_chunks_to_symbols_xx_0</source_block_id><sink_block_id>E3TRadio_zero_order_hold2_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
