<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.9'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>cdma</value></param>
<param><key>author</key><value>Homero Ortega. Universidad industrial de Santander</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>run</key><value>run_stop</value></param>
<param><key>title</key><value>BPSK_Decisor</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>B</value></param>
<param><key>value</key><value>3000000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>BW</value></param>
<param><key>value</key><value>B/2</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>Bps1</value></param>
<param><key>value</key><value>int(math.log(len(Constelacion1),2))</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>Canal_Foffset</value></param>
<param><key>value</key><value>0.</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>Canal_Ruido</value></param>
<param><key>value</key><value>0.1</value></param>
<param><key>gui_hint</key><value>0,1,1,1</value></param>
<param><key>label</key><value>Ruido en el canal</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0.</value></param>
<param><key>step</key><value>1./1000.</value></param>
<param><key>stop</key><value>1.</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>Canal_phi_offset</value></param>
<param><key>value</key><value>0.</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>ChipsSysDelay</value></param>
<param><key>value</key><value>28</value></param>
<param><key>gui_hint</key><value>0,2,1,1</value></param>
<param><key>label</key><value>Retardo en chips del sistema Tx-Rx</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>500</value></param>
<param><key>rangeType</key><value>int</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>Constelacion1</value></param>
<param><key>value</key><value>[1.  +  1.j,  -1  +  1.j,   -1.  -  1.j,   1.  -  1.j ]</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>Fc</value></param>
<param><key>value</key><value>80e6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>Nscope_span</value></param>
<param><key>value</key><value>6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>Rb1</value></param>
<param><key>value</key><value>Rs*Bps1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>Rch</value></param>
<param><key>value</key><value>2000000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>RollOff</value></param>
<param><key>value</key><value>(B-Rch)/float(Rch)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>Rs</value></param>
<param><key>value</key><value>125000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>SF</value></param>
<param><key>value</key><value>int(Rch/Rs)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>SymSysDelay</value></param>
<param><key>value</key><value>int(math.ceil(float(ChipsSysDelay)/SF))</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>c1</value></param>
<param><key>value</key><value>[random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1,random.randint(0,1)*2-1]</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>c1</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>value</key><value>[1,1,1,1,-1,-1,-1,-1]</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>c1</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>value</key><value>[cmath.exp(0*2*math.pi*1j/SF), cmath.exp(1*2*math.pi*1j/SF), cmath.exp(2*2*math.pi*1j/SF), cmath.exp(3*2*math.pi*1j/SF), cmath.exp(4*2*math.pi*1j/SF), cmath.exp(5*2*math.pi*1j/SF), cmath.exp(6*2*math.pi*1j/SF), cmath.exp(7*2*math.pi*1j/SF)]</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>c1_conj</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>value</key><value>[cmath.exp(-0*2*math.pi*1j/SF), cmath.exp(-1*2*math.pi*1j/SF), cmath.exp(-2*2*math.pi*1j/SF), cmath.exp(-3*2*math.pi*1j/SF), cmath.exp(-4*2*math.pi*1j/SF), cmath.exp(-5*2*math.pi*1j/SF), cmath.exp(-6*2*math.pi*1j/SF), cmath.exp(-7*2*math.pi*1j/SF)]</value></param>
</block>
<block>
<key>variable_qtgui_check_box</key>
<param><key>id</key><value>run_stop</value></param>
<param><key>value</key><value>True</value></param>
<param><key>false</key><value>False</value></param>
<param><key>gui_hint</key><value>0,0</value></param>
<param><key>true</key><value>True</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>Rch*spch</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>spch</value></param>
<param><key>value</key><value>4</value></param>
</block>
<block>
<key>E3TRadio_zero_order_hold2_cc</key>
<param><key>id</key><value>E3TRadio_zero_order_hold2_cc_0</value></param>
<param><key>k</key><value>spch</value></param>
</block>
<block>
<key>qtgui_tab_widget</key>
<param><key>id</key><value>Instrumentos</value></param>
<param><key>gui_hint</key><value>1,0,1,3</value></param>
<param><key>label0</key><value>Tx tiempo</value></param>
<param><key>label1</key><value>PSD</value></param>
<param><key>label2</key><value>Tunning</value></param>
<param><key>label3</key><value>Rx tiempo</value></param>
<param><key>label4</key><value>Constelaciones</value></param>
<param><key>num_tabs</key><value>5</value></param>
</block>
<block>
<key>b_Eye_Diagram</key>
<param><key>id</key><value>b_Eye_Diagram_0</value></param>
<param><key>AlphaLineas</key><value>0.5</value></param>
<param><key>Delay</key><value>0</value></param>
<param><key>gui_hint</key><value>Instrumentos@3:2,0,1,1</value></param>
<param><key>GrosorLineas</key><value>20</value></param>
<param><key>N_eyes</key><value>2</value></param>
<param><key>Samprate</key><value>samp_rate</value></param>
<param><key>Sps</key><value>SF</value></param>
<param><key>Title</key><value>"Rx. b_de_ds_spreadspect_cc. Diagrama de Ojo"</value></param>
<param><key>Ymax</key><value>.15</value></param>
<param><key>Ymin</key><value>-.15</value></param>
</block>
<block>
<key>b_MS</key>
<param><key>id</key><value>b_MS_1_0</value></param>
<param><key>N</key><value>1</value></param>
<param><key>Constelacion</key><value>Constelacion1</value></param>
</block>
<block>
<key>b_Raised_cosine</key>
<param><key>id</key><value>b_Raised_cosine_0</value></param>
<param><key>ntaps</key><value>spch*4</value></param>
<param><key>rolloff</key><value>RollOff</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>sps</key><value>spch</value></param>
</block>
<block>
<key>b_USRP_2_USRP</key>
<param><key>id</key><value>b_USRP_2_USRP_0_0</value></param>
<param><key>B</key><value>B</value></param>
<param><key>Fc</key><value>Fc</value></param>
<param><key>Foffset</key><value>Canal_Foffset</value></param>
<param><key>Katt</key><value>10.</value></param>
<param><key>Phoffset</key><value>Canal_phi_offset</value></param>
<param><key>Toffset</key><value>0</value></param>
<param><key>Vruido</key><value>Canal_Ruido</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
</block>
<block>
<key>b_de_ds_spreadspect_cc</key>
<param><key>id</key><value>b_de_ds_spreadspect_cc_0</value></param>
<param><key>ChipsSysDelay</key><value>ChipsSysDelay</value></param>
<param><key>SF</key><value>SF</value></param>
<param><key>codigo</key><value>c1</value></param>
</block>
<block>
<key>b_ds_spreadspect_cc</key>
<param><key>id</key><value>b_ds_spreadspect_cc_0</value></param>
<param><key>SF</key><value>SF</value></param>
<param><key>codigo</key><value>c1</value></param>
</block>
<block>
<key>b_tunner_sampler</key>
<param><key>id</key><value>b_tunner_sampler_0</value></param>
<param><key>AlphaLineasOjo</key><value>0.5</value></param>
<param><key>DelayTuningInicial</key><value>0</value></param>
<param><key>gui_hint</key><value>Instrumentos@2:1,0,1,1</value></param>
<param><key>GrosorLineasOjo</key><value>20</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>sps</key><value>spch</value></param>
</block>
<block>
<key>blocks_complex_to_float</key>
<param><key>id</key><value>blocks_complex_to_float_0</value></param>
</block>
<block>
<key>blocks_complex_to_float</key>
<param><key>id</key><value>blocks_complex_to_float_0_0</value></param>
</block>
<block>
<key>blocks_delay</key>
<param><key>id</key><value>blocks_delay_0</value></param>
<param><key>delay</key><value>SymSysDelay</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0</value></param>
<param><key>const</key><value>0.1</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_null_source</key>
<param><key>id</key><value>blocks_null_source_0</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>num_outputs</key><value>3</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0</value></param>
<param><key>samples_per_second</key><value>samp_rate</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>import math</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0_1</value></param>
<param><key>import</key><value>import cmath</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0_1_0_0</value></param>
<param><key>import</key><value>import random</value></param>
</block>
<block>
<key>low_pass_filter</key>
<param><key>id</key><value>low_pass_filter_0_0</value></param>
<param><key>cutoff_freq</key><value>BW</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>type</key><value>fir_filter_ccf</value></param>
<param><key>gain</key><value>1</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>width</key><value>BW/64.</value></param>
<param><key>win</key><value>firdes.WIN_HAMMING</value></param>
</block>
<block>
<key>low_pass_filter</key>
<param><key>id</key><value>low_pass_filter_0_0_0</value></param>
<param><key>cutoff_freq</key><value>Rs</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>type</key><value>fir_filter_ccf</value></param>
<param><key>gain</key><value>1</value></param>
<param><key>samp_rate</key><value>Rch</value></param>
<param><key>width</key><value>Rs/16.</value></param>
<param><key>win</key><value>firdes.WIN_HAMMING</value></param>
</block>
<block>
<key>low_pass_filter</key>
<param><key>id</key><value>low_pass_filter_0_0_0_0</value></param>
<param><key>cutoff_freq</key><value>Rs</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>type</key><value>fir_filter_ccf</value></param>
<param><key>gain</key><value>1</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>width</key><value>Rs/16.</value></param>
<param><key>win</key><value>firdes.WIN_HAMMING</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>note</key><value>COD. DE WALSH</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_0_0</value></param>
<param><key>note</key><value>COD. PN</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_0_1_0_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>note</key><value>COD. EXP(j*k*2*pi/N)</value></param>
</block>
<block>
<key>qtgui_const_sink_x</key>
<param><key>id</key><value>qtgui_const_sink_x_0</value></param>
<param><key>gui_hint</key><value>Instrumentos@4:1,0,1,1</value></param>
<param><key>label1</key><value>Tx</value></param>
<param><key>name</key><value>"Tx- usuario"</value></param>
<param><key>size</key><value>1024</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>qtgui_const_sink_x</key>
<param><key>id</key><value>qtgui_const_sink_x_0_0</value></param>
<param><key>gui_hint</key><value>Instrumentos@4:2,0,1,2</value></param>
<param><key>label1</key><value>Tx</value></param>
<param><key>name</key><value></value></param>
<param><key>size</key><value>1024</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>xmax</key><value>0.2</value></param>
<param><key>xmin</key><value>-0.2</value></param>
<param><key>ymax</key><value>0.2</value></param>
<param><key>ymin</key><value>-0.2</value></param>
</block>
<block>
<key>qtgui_const_sink_x</key>
<param><key>id</key><value>qtgui_const_sink_x_0_0_1</value></param>
<param><key>gui_hint</key><value>Instrumentos@4:3,0,1,2</value></param>
<param><key>label1</key><value>Tx</value></param>
<param><key>name</key><value></value></param>
<param><key>size</key><value>1024</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>xmax</key><value>0.2</value></param>
<param><key>xmin</key><value>-0.2</value></param>
<param><key>ymax</key><value>0.2</value></param>
<param><key>ymin</key><value>-0.2</value></param>
</block>
<block>
<key>qtgui_const_sink_x</key>
<param><key>id</key><value>qtgui_const_sink_x_0_0_1_0_0</value></param>
<param><key>gui_hint</key><value>Instrumentos@1:2,0,1,1</value></param>
<param><key>label1</key><value>Tx</value></param>
<param><key>name</key><value></value></param>
<param><key>size</key><value>1024</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>xmax</key><value>0.2</value></param>
<param><key>xmin</key><value>-0.2</value></param>
<param><key>ymax</key><value>0.2</value></param>
<param><key>ymin</key><value>-0.2</value></param>
</block>
<block>
<key>qtgui_const_sink_x</key>
<param><key>id</key><value>qtgui_const_sink_x_0_0_2</value></param>
<param><key>gui_hint</key><value>Instrumentos@4:1,1,1,1</value></param>
<param><key>label1</key><value>En el canal</value></param>
<param><key>width1</key><value>4</value></param>
<param><key>label2</key><value>Salida del multiplicador</value></param>
<param><key>width2</key><value>6</value></param>
<param><key>label3</key><value>salida del muestreador</value></param>
<param><key>width3</key><value>12</value></param>
<param><key>name</key><value>"Rx"</value></param>
<param><key>nconnections</key><value>3</value></param>
<param><key>size</key><value>1024</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>xmax</key><value>0.2</value></param>
<param><key>xmin</key><value>-0.2</value></param>
<param><key>ymax</key><value>0.2</value></param>
<param><key>ymin</key><value>-0.2</value></param>
</block>
<block>
<key>qtgui_freq_sink_x</key>
<param><key>id</key><value>qtgui_freq_sink_x_0</value></param>
<param><key>average</key><value>0.05</value></param>
<param><key>bw</key><value>Rch</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>ctrlpanel</key><value>True</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>gui_hint</key><value>Instrumentos@1:0,0,1,1</value></param>
<param><key>label1</key><value>Tx.Info del usuario</value></param>
<param><key>width1</key><value>3</value></param>
<param><key>label2</key><value>Tx. Senal ensanchada</value></param>
<param><key>nconnections</key><value>2</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
<param><key>ymin</key><value>-80</value></param>
</block>
<block>
<key>qtgui_freq_sink_x</key>
<param><key>id</key><value>qtgui_freq_sink_x_0_0</value></param>
<param><key>average</key><value>0.05</value></param>
<param><key>bw</key><value>samp_rate</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>ctrlpanel</key><value>True</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>gui_hint</key><value>Instrumentos@1:1,0,1,1</value></param>
<param><key>label1</key><value>Tx.Info del usuario</value></param>
<param><key>width1</key><value>3</value></param>
<param><key>label2</key><value>Rx.Salida del USRP_2_USRP</value></param>
<param><key>nconnections</key><value>2</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
<param><key>ymin</key><value>-80</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0_0</value></param>
<param><key>ctrlpanel</key><value>True</value></param>
<param><key>gui_hint</key><value>Instrumentos@0:1,0,1,1</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value>Re</value></param>
<param><key>color2</key><value>"red"</value></param>
<param><key>label2</key><value>Im</value></param>
<param><key>name</key><value>"Tx.cod"</value></param>
<param><key>size</key><value>Nscope_span*SF</value></param>
<param><key>srate</key><value>Rch</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0_0_0</value></param>
<param><key>ctrlpanel</key><value>True</value></param>
<param><key>gui_hint</key><value>Instrumentos@0:2,0,1,1</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value>Re</value></param>
<param><key>color2</key><value>"red"</value></param>
<param><key>label2</key><value>Im</value></param>
<param><key>name</key><value>"Tx.senal ds ss"</value></param>
<param><key>size</key><value>Nscope_span*SF</value></param>
<param><key>srate</key><value>Rch</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0_0_0_0</value></param>
<param><key>ctrlpanel</key><value>True</value></param>
<param><key>gui_hint</key><value>Instrumentos@3:1,0,1,1</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>color2</key><value>"red"</value></param>
<param><key>label2</key><value></value></param>
<param><key>name</key><value>"Rx.Multiplicador del de_ds_spreadspect_cc"</value></param>
<param><key>size</key><value>Nscope_span*SF</value></param>
<param><key>srate</key><value>Rch</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>ymax</key><value>0.2</value></param>
<param><key>ymin</key><value>-0.2</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0_0_0_1</value></param>
<param><key>ctrlpanel</key><value>True</value></param>
<param><key>gui_hint</key><value>Instrumentos@0:3,0,1,1</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value>Re</value></param>
<param><key>color2</key><value>"red"</value></param>
<param><key>label2</key><value>Im</value></param>
<param><key>name</key><value>"Tx.salida del Raised Cosine"</value></param>
<param><key>size</key><value>Nscope_span*SF*spch</value></param>
<param><key>srate</key><value>samp_rate</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0_0_1</value></param>
<param><key>ctrlpanel</key><value>True</value></param>
<param><key>gui_hint</key><value>Instrumentos@3:3,0,1,1</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value>Tx (Re)</value></param>
<param><key>color2</key><value>"red"</value></param>
<param><key>label2</key><value>Tx(Im)</value></param>
<param><key>color3</key><value>"green"</value></param>
<param><key>label3</key><value>Rx (Re)</value></param>
<param><key>color4</key><value>"black"</value></param>
<param><key>label4</key><value>Rx(Im)</value></param>
<param><key>name</key><value>"comparacion de senal enviada y recibida"</value></param>
<param><key>nconnections</key><value>2</value></param>
<param><key>size</key><value>Nscope_span*SF</value></param>
<param><key>srate</key><value>Rch</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0_1</value></param>
<param><key>ctrlpanel</key><value>True</value></param>
<param><key>gui_hint</key><value>Instrumentos@0:0,0,1,1</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value>Re</value></param>
<param><key>width1</key><value>3</value></param>
<param><key>color2</key><value>"red"</value></param>
<param><key>label2</key><value>Im</value></param>
<param><key>name</key><value>"Tx. Usuario con sobremuestreo"</value></param>
<param><key>size</key><value>Nscope_span*SF</value></param>
<param><key>srate</key><value>Rch</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>ymax</key><value>1.5</value></param>
<param><key>ymin</key><value>-1.5</value></param>
</block>
<block>
<key>rational_resampler_xxx</key>
<param><key>id</key><value>rational_resampler_xxx_0</value></param>
<param><key>decim</key><value>spch</value></param>
<param><key>interp</key><value>1</value></param>
<param><key>taps</key><value></value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<connection><source_block_id>E3TRadio_zero_order_hold2_cc_0</source_block_id><sink_block_id>low_pass_filter_0_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>b_MS_1_0</source_block_id><sink_block_id>b_ds_spreadspect_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>b_MS_1_0</source_block_id><sink_block_id>blocks_delay_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>b_Raised_cosine_0</source_block_id><sink_block_id>blocks_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>b_USRP_2_USRP_0_0</source_block_id><sink_block_id>low_pass_filter_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>b_USRP_2_USRP_0_0</source_block_id><sink_block_id>qtgui_time_sink_x_0_0_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>b_USRP_2_USRP_0_0</source_block_id><sink_block_id>rational_resampler_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>b_de_ds_spreadspect_cc_0</source_block_id><sink_block_id>blocks_complex_to_float_0</sink_block_id><source_key>3</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>b_de_ds_spreadspect_cc_0</source_block_id><sink_block_id>blocks_complex_to_float_0_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>b_de_ds_spreadspect_cc_0</source_block_id><sink_block_id>qtgui_const_sink_x_0_0_2</sink_block_id><source_key>1</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>b_de_ds_spreadspect_cc_0</source_block_id><sink_block_id>qtgui_const_sink_x_0_0_2</sink_block_id><source_key>2</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>b_de_ds_spreadspect_cc_0</source_block_id><sink_block_id>qtgui_time_sink_x_0_0_0_0</sink_block_id><source_key>2</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>b_de_ds_spreadspect_cc_0</source_block_id><sink_block_id>qtgui_time_sink_x_0_0_1</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>b_ds_spreadspect_cc_0</source_block_id><sink_block_id>qtgui_time_sink_x_0_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>b_ds_spreadspect_cc_0</source_block_id><sink_block_id>E3TRadio_zero_order_hold2_cc_0</sink_block_id><source_key>2</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>b_ds_spreadspect_cc_0</source_block_id><sink_block_id>low_pass_filter_0_0_0</sink_block_id><source_key>2</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>b_ds_spreadspect_cc_0</source_block_id><sink_block_id>qtgui_const_sink_x_0</sink_block_id><source_key>2</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>b_ds_spreadspect_cc_0</source_block_id><sink_block_id>qtgui_time_sink_x_0_1</sink_block_id><source_key>2</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>b_ds_spreadspect_cc_0</source_block_id><sink_block_id>b_Raised_cosine_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>b_ds_spreadspect_cc_0</source_block_id><sink_block_id>qtgui_freq_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>b_ds_spreadspect_cc_0</source_block_id><sink_block_id>qtgui_time_sink_x_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>b_tunner_sampler_0</source_block_id><sink_block_id>b_de_ds_spreadspect_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_float_0</source_block_id><sink_block_id>b_Eye_Diagram_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_float_0_0</source_block_id><sink_block_id>b_Eye_Diagram_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_delay_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0</source_block_id><sink_block_id>qtgui_time_sink_x_0_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_null_source_0</source_block_id><sink_block_id>qtgui_const_sink_x_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_null_source_0</source_block_id><sink_block_id>qtgui_const_sink_x_0_0_1</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_null_source_0</source_block_id><sink_block_id>qtgui_const_sink_x_0_0_1_0_0</sink_block_id><source_key>2</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>b_USRP_2_USRP_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>qtgui_freq_sink_x_0_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>low_pass_filter_0_0</source_block_id><sink_block_id>b_tunner_sampler_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>low_pass_filter_0_0_0</source_block_id><sink_block_id>qtgui_freq_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>low_pass_filter_0_0_0_0</source_block_id><sink_block_id>qtgui_freq_sink_x_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rational_resampler_xxx_0</source_block_id><sink_block_id>qtgui_const_sink_x_0_0_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
