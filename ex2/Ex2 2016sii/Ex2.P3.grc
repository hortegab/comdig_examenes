<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.9'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>MPSK</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>run</key><value>run_stop</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>AccumOffset</value></param>
<param><key>value</key><value>0</value></param>
<param><key>gui_hint</key><value>pestana1@0:0,3,1,1</value></param>
<param><key>label</key><value>Offset Accum.</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>Sps-1</value></param>
<param><key>rangeType</key><value>int</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>B</value></param>
<param><key>value</key><value>300000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>Bps</value></param>
<param><key>value</key><value>int(math.log(len(Constelacion),2))</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>Constelacion</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>value</key><value>[.33+.33j, 1+.33j, 1+1.j, .33+1.j,     -.33+.33j, -1+.33j, -1+1.j, -.33+1.j,    -.33-.33j, -1-.33j, -1-1.j, -.33-1.j,     .33-.33j, 1-.33j, 1-1.j, .33-1.j ]</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>Constelacion</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>value</key><value>[1.+0.j,   0.+1.j,   -1.+0.j,  0.-1.j ]</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>Constelacion</value></param>
<param><key>value</key><value>[1.+0.j,   0.707+ 0.707j,   0.+1.j,  -0.707+ 0.707j,  -1.+0.j,  -0.707- 0.707j,  0.-1.j,  0.707- 0.707j]</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>DelayDiez</value></param>
<param><key>value</key><value>int(Sps/2)</value></param>
<param><key>gui_hint</key><value>pestana1@0:0,2,1,1</value></param>
<param><key>label</key><value>Retrazo muestreador</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>Sps-1</value></param>
<param><key>rangeType</key><value>int</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>DelayOjo</value></param>
<param><key>value</key><value>0</value></param>
<param><key>gui_hint</key><value>pestana@6:1,0,1,1</value></param>
<param><key>label</key><value>varie aqui el retrazo de la senal para centrar el ojo</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>Sps</value></param>
<param><key>rangeType</key><value>int</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>Fc</value></param>
<param><key>value</key><value>2000000</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>Foffset</value></param>
<param><key>value</key><value>0</value></param>
<param><key>gui_hint</key><value>pestana1@0:0,0,1,1</value></param>
<param><key>label</key><value>Offset de frec.</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>0.01</value></param>
<param><key>stop</key><value>5</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>Fs_cs</value></param>
<param><key>value</key><value>Rs</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>Fs_pu</value></param>
<param><key>value</key><value>Rs</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>Fs_rs</value></param>
<param><key>value</key><value>Rs/8</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>Fs_uz</value></param>
<param><key>value</key><value>B</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>Kruido</value></param>
<param><key>value</key><value>0.002</value></param>
<param><key>gui_hint</key><value>1,3,1,1</value></param>
<param><key>label</key><value>Nivel del Ruido</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>0.001</value></param>
<param><key>stop</key><value>1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>M</value></param>
<param><key>value</key><value>len(Constelacion)</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>Phioffset</value></param>
<param><key>value</key><value>0</value></param>
<param><key>gui_hint</key><value>pestana1@0:0,1,1,1</value></param>
<param><key>label</key><value>Offset de angulo</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>-3.1415</value></param>
<param><key>step</key><value>0.1</value></param>
<param><key>stop</key><value>3.1415</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>Rb</value></param>
<param><key>value</key><value>Rs*Bps</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>Rs</value></param>
<param><key>value</key><value>B/(1.+rolloff)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>Sps</value></param>
<param><key>value</key><value>16</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>ntaps</value></param>
<param><key>value</key><value>512</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>rolloff</value></param>
<param><key>value</key><value>0.75</value></param>
</block>
<block>
<key>variable_qtgui_check_box</key>
<param><key>id</key><value>run_stop</value></param>
<param><key>value</key><value>True</value></param>
<param><key>false</key><value>False</value></param>
<param><key>gui_hint</key><value>1,0,1,1</value></param>
<param><key>label</key><value>Inicial/Parar</value></param>
<param><key>true</key><value>True</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>E3TRadio_usrp2usrp1_cc</key>
<param><key>id</key><value>E3TRadio_usrp2usrp1_cc_0</value></param>
<param><key>Am</key><value>0.8</value></param>
<param><key>BW</key><value>B/2.</value></param>
<param><key>Katt</key><value>10.</value></param>
<param><key>samp_rate</key><value>Fs_uz</value></param>
<param><key>Vruido</key><value>Kruido</value></param>
<param><key>Phoffset</key><value>numpy.pi/3.0</value></param>
<param><key>Foffset</key><value>0.01</value></param>
<param><key>Toffset</key><value>int(Sps*random.random())</value></param>
</block>
<block>
<key>E3TRadio_zero_order_hold2_cc</key>
<param><key>id</key><value>E3TRadio_zero_order_hold2_cc_0</value></param>
<param><key>k</key><value>Sps</value></param>
</block>
<block>
<key>analog_random_source_x</key>
<param><key>id</key><value>analog_random_source_x_0</value></param>
<param><key>max</key><value>256</value></param>
<param><key>min</key><value>0</value></param>
<param><key>num_samps</key><value>1000</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>repeat</key><value>True</value></param>
</block>
<block>
<key>b_Eye_Diagram</key>
<param><key>id</key><value>b_Eye_Diagram_0</value></param>
<param><key>AlphaLineas</key><value>1.0</value></param>
<param><key>Delay</key><value>DelayOjo</value></param>
<param><key>gui_hint</key><value>pestana@6:0,0,1,1</value></param>
<param><key>GrosorLineas</key><value>1</value></param>
<param><key>N_eyes</key><value>2</value></param>
<param><key>Samprate</key><value>Fs_uz</value></param>
<param><key>Sps</key><value>Sps</value></param>
<param><key>Title</key><value>"Eye Diagramm"</value></param>
<param><key>Ymax</key><value>2</value></param>
<param><key>Ymin</key><value>-2</value></param>
</block>
<block>
<key>b_Raised_cosine</key>
<param><key>id</key><value>b_Raised_cosine_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>ntaps</key><value>ntaps</value></param>
<param><key>rolloff</key><value>rolloff</value></param>
<param><key>samp_rate</key><value>Fs_uz</value></param>
<param><key>sps</key><value>Sps</value></param>
</block>
<block>
<key>b_sampler_cc</key>
<param><key>id</key><value>b_sampler_cc_0</value></param>
<param><key>DelayDiez</key><value>DelayDiez</value></param>
<param><key>Sps</key><value>Sps</value></param>
</block>
<block>
<key>b_tunner</key>
<param><key>id</key><value>b_tunner_0</value></param>
<param><key>fdesv</key><value>-Foffset</value></param>
<param><key>NDelay</key><value>0</value></param>
<param><key>phi</key><value>Phioffset</value></param>
<param><key>samp_rate</key><value>Fs_uz</value></param>
</block>
<block>
<key>blocks_complex_to_real</key>
<param><key>id</key><value>blocks_complex_to_real_0</value></param>
</block>
<block>
<key>blocks_delay</key>
<param><key>id</key><value>blocks_delay_0</value></param>
<param><key>delay</key><value>DelayOjo</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_multiply_xx</key>
<param><key>id</key><value>blocks_multiply_xx_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_packed_to_unpacked_xx</key>
<param><key>id</key><value>blocks_packed_to_unpacked_xx_0</value></param>
<param><key>bits_per_chunk</key><value>Bps</value></param>
<param><key>endianness</key><value>gr.GR_MSB_FIRST</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0</value></param>
<param><key>samples_per_second</key><value>Fs_uz</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_vector_source_x</key>
<param><key>id</key><value>blocks_vector_source_x_0_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>repeat</key><value>True</value></param>
<param><key>vector</key><value>(3,2,0,0,0,0,0,0,0,0,0,0,0,0,0,0)</value></param>
</block>
<block>
<key>blocks_vector_source_x</key>
<param><key>id</key><value>blocks_vector_source_x_0_0_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>repeat</key><value>True</value></param>
<param><key>vector</key><value>(1+0j,1+0j, 0+0j, 0+0j, 0+0j, 0+0j, 0+0j, 0+0j, 0+0j, 0+0j, 0+0j, 0+0j, 0+0j, 0+0j, 0+0j, 0+0j)</value></param>
</block>
<block>
<key>digital_chunks_to_symbols_xx</key>
<param><key>id</key><value>digital_chunks_to_symbols_xx_0</value></param>
<param><key>dimension</key><value>1</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>in_type</key><value>byte</value></param>
<param><key>out_type</key><value>complex</value></param>
<param><key>symbol_table</key><value>Constelacion</value></param>
</block>
<block>
<key>digital_chunks_to_symbols_xx</key>
<param><key>id</key><value>digital_chunks_to_symbols_xx_0_0</value></param>
<param><key>dimension</key><value>1</value></param>
<param><key>in_type</key><value>byte</value></param>
<param><key>out_type</key><value>complex</value></param>
<param><key>symbol_table</key><value>Constelacion</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>import math</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0_0</value></param>
<param><key>import</key><value>import numpy</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0_0_0</value></param>
<param><key>import</key><value>import random</value></param>
</block>
<block>
<key>qtgui_tab_widget</key>
<param><key>id</key><value>pestana</value></param>
<param><key>label0</key><value>Tx Envolente compleja</value></param>
<param><key>label1</key><value>TX Espectro</value></param>
<param><key>label2</key><value>RX Envolvente Compleja </value></param>
<param><key>label3</key><value>RX Espectro</value></param>
<param><key>label4</key><value>Tx Constelaciones</value></param>
<param><key>label5</key><value>Rx Constelaciones</value></param>
<param><key>label6</key><value>Diagrama de Ojo</value></param>
<param><key>num_tabs</key><value>7</value></param>
</block>
<block>
<key>qtgui_tab_widget</key>
<param><key>id</key><value>pestana1</value></param>
<param><key>label0</key><value>Rx Sintonia</value></param>
<param><key>num_tabs</key><value>1</value></param>
</block>
<block>
<key>qtgui_const_sink_x</key>
<param><key>id</key><value>qtgui_const_sink_x_0</value></param>
<param><key>gui_hint</key><value>pestana@4:0,1,1,1</value></param>
<param><key>label1</key><value>Conste</value></param>
<param><key>style1</key><value>1</value></param>
<param><key>name</key><value>"Tx - Filtro RC o Zehoh"</value></param>
<param><key>size</key><value>1024</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>xmax</key><value>1.5</value></param>
<param><key>xmin</key><value>-1.5</value></param>
<param><key>ymax</key><value>1.5</value></param>
<param><key>ymin</key><value>-1.5</value></param>
</block>
<block>
<key>qtgui_const_sink_x</key>
<param><key>id</key><value>qtgui_const_sink_x_0_1</value></param>
<param><key>gui_hint</key><value>pestana@5:0,0,1,1</value></param>
<param><key>label1</key><value>Rx Tunner</value></param>
<param><key>style1</key><value>1</value></param>
<param><key>label2</key><value>Rx Muestreador</value></param>
<param><key>name</key><value>"Rx - Tunner versus muestreador"</value></param>
<param><key>nconnections</key><value>2</value></param>
<param><key>size</key><value>1024</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>xmax</key><value>.15</value></param>
<param><key>xmin</key><value>-.15</value></param>
<param><key>ymax</key><value>.15</value></param>
<param><key>ymin</key><value>-.15</value></param>
</block>
<block>
<key>qtgui_const_sink_x</key>
<param><key>id</key><value>qtgui_const_sink_x_0_1_0</value></param>
<param><key>gui_hint</key><value>pestana@5:0,1,1,1</value></param>
<param><key>color1</key><value>"red"</value></param>
<param><key>label1</key><value>Conste</value></param>
<param><key>name</key><value>"Rx - Muestreador"</value></param>
<param><key>size</key><value>1024</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>xmax</key><value>.15</value></param>
<param><key>xmin</key><value>-.15</value></param>
<param><key>ymax</key><value>.15</value></param>
<param><key>ymin</key><value>-.15</value></param>
</block>
<block>
<key>qtgui_const_sink_x</key>
<param><key>id</key><value>qtgui_const_sink_x_0_2</value></param>
<param><key>gui_hint</key><value>pestana@4:0,0,1,1</value></param>
<param><key>label1</key><value>Conste</value></param>
<param><key>style1</key><value>1</value></param>
<param><key>name</key><value>"Tx - bloque Chunks to Symbols"</value></param>
<param><key>size</key><value>1024</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>qtgui_freq_sink_x</key>
<param><key>id</key><value>qtgui_freq_sink_x_0</value></param>
<param><key>average</key><value>0.05</value></param>
<param><key>bw</key><value>Fs_uz</value></param>
<param><key>fc</key><value>Fc</value></param>
<param><key>ctrlpanel</key><value>True</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>gui_hint</key><value>pestana@1:0,0,1,2</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>qtgui_freq_sink_x</key>
<param><key>id</key><value>qtgui_freq_sink_x_0_0</value></param>
<param><key>average</key><value>0.05</value></param>
<param><key>bw</key><value>Fs_uz</value></param>
<param><key>fc</key><value>Fc</value></param>
<param><key>ctrlpanel</key><value>True</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>gui_hint</key><value>pestana@3:0,0,1,2</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_1_0</value></param>
<param><key>ctrlpanel</key><value>True</value></param>
<param><key>gui_hint</key><value>pestana@2:0,0,1,2</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value>I</value></param>
<param><key>color2</key><value>"red"</value></param>
<param><key>label2</key><value>Q</value></param>
<param><key>size</key><value>Sps*64</value></param>
<param><key>srate</key><value>Fs_uz</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>ymax</key><value>0.2</value></param>
<param><key>ymin</key><value>-0.2</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_1_1</value></param>
<param><key>ctrlpanel</key><value>True</value></param>
<param><key>gui_hint</key><value>pestana@0:1,0,1,2</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value>I</value></param>
<param><key>color2</key><value>"red"</value></param>
<param><key>label2</key><value>Q</value></param>
<param><key>name</key><value>"Senal Modulada"</value></param>
<param><key>size</key><value>Sps*64</value></param>
<param><key>srate</key><value>Fs_uz</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<connection><source_block_id>E3TRadio_usrp2usrp1_cc_0</source_block_id><sink_block_id>b_tunner_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>E3TRadio_usrp2usrp1_cc_0</source_block_id><sink_block_id>blocks_complex_to_real_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>E3TRadio_zero_order_hold2_cc_0</source_block_id><sink_block_id>blocks_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_random_source_x_0</source_block_id><sink_block_id>blocks_packed_to_unpacked_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>b_Raised_cosine_0</source_block_id><sink_block_id>blocks_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>b_sampler_cc_0</source_block_id><sink_block_id>qtgui_const_sink_x_0_1</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>b_sampler_cc_0</source_block_id><sink_block_id>qtgui_const_sink_x_0_1_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>b_tunner_0</source_block_id><sink_block_id>b_sampler_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>b_tunner_0</source_block_id><sink_block_id>qtgui_const_sink_x_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>b_tunner_0</source_block_id><sink_block_id>qtgui_freq_sink_x_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>b_tunner_0</source_block_id><sink_block_id>qtgui_time_sink_x_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_real_0</source_block_id><sink_block_id>blocks_delay_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_delay_0</source_block_id><sink_block_id>b_Eye_Diagram_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_delay_0</source_block_id><sink_block_id>b_Eye_Diagram_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_multiply_xx_0</source_block_id><sink_block_id>b_Raised_cosine_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_packed_to_unpacked_xx_0</source_block_id><sink_block_id>digital_chunks_to_symbols_xx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>E3TRadio_usrp2usrp1_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>qtgui_const_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>qtgui_freq_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>qtgui_time_sink_x_1_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vector_source_x_0_0</source_block_id><sink_block_id>digital_chunks_to_symbols_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vector_source_x_0_0_0</source_block_id><sink_block_id>blocks_multiply_xx_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>digital_chunks_to_symbols_xx_0</source_block_id><sink_block_id>blocks_multiply_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_chunks_to_symbols_xx_0_0</source_block_id><sink_block_id>E3TRadio_zero_order_hold2_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_chunks_to_symbols_xx_0_0</source_block_id><sink_block_id>b_Raised_cosine_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_chunks_to_symbols_xx_0_0</source_block_id><sink_block_id>qtgui_const_sink_x_0_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
