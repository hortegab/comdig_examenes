options:
  parameters:
    generate_options: qt_gui
    id: top_block
    output_language: python
    run: run_stop
  states: {}

blocks:
- name: Ancho_de_Banda
  id: variable
  parameters:
    value: (Rb/2)*(1+0.3)
  states: {}
- name: BW
  id: variable
  parameters:
    value: '52000'
  states: {}
- name: Bits_vecinos_afectados
  id: variable
  parameters:
    value: ((ntaps)/Sps)-1
  states: {}
- name: Channel_BW
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,0,1,1
    label: Channel_BW
    orient: Qt.Horizontal
    start: '0.'
    step: (samp_rate/2)/100.
    stop: samp_rate/2.
    value: samp_rate/2.
  states: {}
- name: Fmax
  id: variable
  parameters:
    value: samp_rate/2
  states: {}
- name: Fresol
  id: variable
  parameters:
    value: samp_rate/N
  states: {}
- name: Fs_T4
  id: variable
  parameters:
    value: Rb
  states: {}
- name: N
  id: variable
  parameters:
    value: '1024'
  states: {}
- name: No_dB
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,1,1,1
    label: No (dB)
    orient: Qt.Horizontal
    start: '-300'
    step: 300/100.
    stop: '0'
    value: '-60'
  states: {}
- name: Rb
  id: variable
  parameters:
    value: '80000'
  states: {}
- name: Resolución_Espectral
  id: variable
  parameters:
    value: samp_rate/N
  states: {}
- name: Rolloff
  id: variable
  parameters:
    value: '0.3'
  states: {}
- name: SPAN
  id: variable
  parameters:
    value: samp_rate/2
  states: {}
- name: Sps
  id: variable
  parameters:
    value: '4'
  states: {}
- name: W
  id: variable
  parameters:
    value: BW/(1+Rolloff)
  states: {}
- name: h
  id: variable
  parameters:
    value: wform.rcos(Sps,ntaps,Rolloff)
  states: {}
- name: ntaps
  id: variable
  parameters:
    value: '32'
  states: {}
- name: run_stop
  id: variable_qtgui_check_box
  parameters:
    'false': 'False'
    gui_hint: 0,0,1,1
    label: Pause
    'true': 'True'
    type: int
    value: 'True'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: Rb*Sps
  states: {}
- name: E3TRadio_decisor_fb_0
  id: E3TRadio_decisor_fb
  parameters:
    Umbral: '0.'
  states: {}
- name: E3TRadio_diezma_ff_0
  id: E3TRadio_diezma_ff
  parameters:
    M: '2'
    N: Sps
  states: {}
- name: E3TRadio_unipolar_to_bipolar_ff_0
  id: E3TRadio_unipolar_to_bipolar_ff
  parameters:
    Amp: '1.'
  states: {}
- name: b_Canal_AWGN_ff_0
  id: b_Canal_AWGN_ff
  parameters:
    BW: Channel_BW
    Ch_NodB: No_dB
    Ch_Toffset: '0'
    samp_rate: int(samp_rate)
  states: {}
- name: b_PSD_0_0
  id: b_PSD
  parameters:
    Ensayos: '1000000'
    N: '1024'
    Titulo: '''PSD in T3'''
    Ymax: '1e-5'
    gui_hint: menu@0:0,0,1,1
    samp_rate_audio: samp_rate
  states: {}
- name: b_PSD_0_0_0
  id: b_PSD
  parameters:
    Ensayos: '1000000'
    N: '1024'
    Titulo: '''PSD in  R3'''
    Ymax: '1e-5'
    gui_hint: menu@0:1,0,1,1
    samp_rate_audio: samp_rate
  states: {}
- name: b_binary_bipolar_source_f_0
  id: b_binary_bipolar_source_f
  parameters:
    Am: '1.'
    Spb: '1'
  states: {}
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_delay_0_1
  id: blocks_delay
  parameters:
    delay: '0'
    type: float
  states: {}
- name: blocks_delay_0_1_0
  id: blocks_delay
  parameters:
    delay: '0'
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '1.'
    type: float
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: interp_fir_filter_xxx_0
  id: interp_fir_filter_xxx
  parameters:
    interp: Sps
    taps: h
    type: fff
  states: {}
- name: menu
  id: qtgui_tab_widget
  parameters:
    gui_hint: 2,0,1,2
    label0: Punto1
    label1: Punto3
    num_tabs: '2'
  states: {}
- name: note_0
  id: note
  parameters:
    note: Rolloff=0.3
  states: {}
- name: note_1
  id: note
  parameters:
    note: Datos entrada
  states: {}
- name: note_10
  id: note
  parameters:
    note: Punto1
  states: {}
- name: note_11
  id: note
  parameters:
    note: N=1024
  states: {}
- name: note_12
  id: note
  parameters:
    note: Solución
  states: {}
- name: note_13
  id: note
  parameters:
    note: Punto2
  states: {}
- name: note_2
  id: note
  parameters:
    note: Rb=80Kbps
  states: {}
- name: note_3
  id: note
  parameters:
    note: Sps=4
  states: {}
- name: note_4
  id: note
  parameters:
    note: Fmax=152.38kHz
  states: {}
- name: note_5
  id: note
  parameters:
    note: Bw=52KHz
  states: {}
- name: note_6
  id: note
  parameters:
    note: Tania Valentina Castellanos Parada-2162039
  states: {}
- name: note_7
  id: note
  parameters:
    note: Ntaps=32
  states: {}
- name: note_9
  id: note
  parameters:
    note: Punto3
  states: {}
- name: qtgui_time_sink_x_0_1
  id: qtgui_time_sink_x
  parameters:
    gui_hint: menu@1:1,0,1,2
    label1: ''
    marker1: '0'
    size: '32'
    srate: Rb
    stemplot: 'True'
    type: float
    width1: '2'
    ylabel: input of the waveform filter
    ymax: '1.5'
    ymin: '-1.5'
  states: {}
- name: qtgui_time_sink_x_0_1_0
  id: qtgui_time_sink_x
  parameters:
    gui_hint: menu@1:2,0,1,2
    label1: ''
    marker1: '0'
    size: 32*Sps
    srate: samp_rate
    style1: '3'
    type: float
    width1: '3'
    ylabel: output of  waveform filter
    ymax: '1.5'
    ymin: '-1.5'
  states: {}
- name: vs_0
  id: virtual_sink
  parameters:
    stream_id: T3
  states: {}
- name: vs_0_0
  id: virtual_sink
  parameters:
    stream_id: R3
  states: {}
- name: vs_0_0_1
  id: virtual_sink
  parameters:
    stream_id: R4
  states: {}
- name: vs_0_2
  id: virtual_sink
  parameters:
    stream_id: T4
  states: {}
- name: vso_0_0
  id: virtual_source
  parameters:
    stream_id: T3
  states: {}
- name: vso_0_1_0
  id: virtual_source
  parameters:
    stream_id: R3
  states: {}
- name: vso_0_1_0_0_0_2
  id: virtual_source
  parameters:
    stream_id: T4
  states: {}
- name: vso_0_1_0_0_0_2_0
  id: virtual_source
  parameters:
    stream_id: T3
  states: {}
- name: wform
  id: epy_module
  parameters:
    source_code: |
      import math
      import numpy
      #######################################################
      ##        Hecho por Homero Ortega Boada              ##
      ##        comdiguis@saber.uis.edu.co                 ##
      ##     Universidad Industrial de Santander           ##
      #######################################################

      #######################################################
      ##               Forma rectangular                   ##
      #######################################################                       
      def rect(Sps):
          return Sps*[1.,]

      #######################################################
      ##               Forma de Nyquist                    ##
      #######################################################                       
      def nyq(Sps,ntaps):
          n=numpy.linspace(-int(ntaps/2), int(ntaps/2-1),ntaps)
          h=numpy.sinc(n/Sps)
      #    return h/numpy.amax(h)
          return h
      #######################################################
      ##               Forma Coseno Alzado                 ##
      #######################################################                       
      def rcos(Sps,ntaps,beta):
          if beta==0:
              h=nyq(Sps,ntaps)
          else:
              h=ntaps*[0,]
              for n in range(ntaps):
                  k=n-ntaps/2. # esto es para que h[n] quede centrada en la mitad del vector
                  if abs(k)==Sps/(2.*beta):
                      h[n]=numpy.sinc(1./(2.*beta))*math.pi/4.
                  else:
                      h[n]=numpy.sinc(k/Sps)*math.cos(beta*k*math.pi/Sps)/(1.-(2.*beta*k/Sps)**2)                
          Amp=numpy.amax(h)
          return h/Amp
      #######################################################
      ##            Forma Raiz de Coseno Alzado            ##
      #######################################################                       

      def rrcos(Sps,ntaps,beta):
          if beta==0:
              h=nyq(Sps,ntaps)
          else:
              h=ntaps*[0,]
              beta4=4.*beta
              for n in range(ntaps):
                  k=n-ntaps/2. # esto es para que h[n] quede centrada en la mitad del vector
                  if k==0:
                      h[n]=1+beta*(4./math.pi-1.)
                  elif abs(k)==Sps/beta4:
                      ha=(1.+2./math.pi)*math.sin(math.pi/beta4)
                      hb=(1.-2./math.pi)*math.cos(math.pi/beta4)
                      h[n]=(ha+hb)*beta/math.sqrt(2.)
                  else:
                      ks=k/Sps
                      kspi=math.pi*ks
                      Num=math.sin(kspi*(1-beta))+beta4*ks*math.cos(kspi*(1+beta))
                      Den=kspi*(1.-(beta4*ks)**2)
                      h[n]=Num/Den                
          Amp=numpy.amax(h)
          return h/Amp
  states: {}

connections:
- [E3TRadio_decisor_fb_0, '0', blocks_char_to_float_0, '0']
- [E3TRadio_diezma_ff_0, '0', E3TRadio_decisor_fb_0, '0']
- [E3TRadio_unipolar_to_bipolar_ff_0, '0', blocks_null_sink_0, '0']
- [E3TRadio_unipolar_to_bipolar_ff_0, '0', vs_0_0_1, '0']
- [b_Canal_AWGN_ff_0, '0', blocks_multiply_const_vxx_0, '0']
- [b_binary_bipolar_source_f_0, '0', interp_fir_filter_xxx_0, '0']
- [b_binary_bipolar_source_f_0, '0', vs_0_2, '0']
- [blocks_char_to_float_0, '0', E3TRadio_unipolar_to_bipolar_ff_0, '0']
- [blocks_delay_0_1, '0', qtgui_time_sink_x_0_1_0, '0']
- [blocks_delay_0_1_0, '0', qtgui_time_sink_x_0_1, '0']
- [blocks_multiply_const_vxx_0, '0', E3TRadio_diezma_ff_0, '0']
- [blocks_multiply_const_vxx_0, '0', vs_0_0, '0']
- [interp_fir_filter_xxx_0, '0', b_Canal_AWGN_ff_0, '0']
- [interp_fir_filter_xxx_0, '0', vs_0, '0']
- [vso_0_0, '0', b_PSD_0_0, '0']
- [vso_0_1_0, '0', b_PSD_0_0_0, '0']
- [vso_0_1_0_0_0_2, '0', blocks_delay_0_1_0, '0']
- [vso_0_1_0_0_0_2_0, '0', blocks_delay_0_1, '0']

metadata:
  file_format: 1
