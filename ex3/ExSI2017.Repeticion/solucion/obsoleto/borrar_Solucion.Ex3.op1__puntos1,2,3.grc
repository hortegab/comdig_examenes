<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.9'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>z_OFDM_Multiusuario</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>run</key><value>run_stop</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>B</value></param>
<param><key>value</key><value>Rs*N</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>Bps</value></param>
<param><key>value</key><value>int(math.log(M,2))</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>Constelacion</value></param>
<param><key>value</key><value>[(1+1.j)/4.24,(3+1.j)/4.24,(3+3.j)/4.24,(1+3.j)/4.24,(-1+1.j)/4.24,(-3+1.j)/4.24,(-3+3.j)/4.24,(-1+3.j)/4.24,(-1-1.j)/4.24,(-3-1.j)/4.24,(-3-3.j)/4.24,(-1-3.j)/4.24,(1-1.j)/4.24,(3-1.j)/4.24,(3-3.j)/4.24,(1-3.j)/4.24]</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>Es</value></param>
<param><key>value</key><value>math.pow(10,Es_dB/10.)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>Es_No_dB</value></param>
<param><key>value</key><value>20</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>Es_dB</value></param>
<param><key>value</key><value>Es_No_dB+No_dB</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>Fc</value></param>
<param><key>value</key><value>900000000</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>Kruido</value></param>
<param><key>value</key><value>0.01</value></param>
<param><key>gui_hint</key><value>1,0,1,1</value></param>
<param><key>label</key><value>Nivel del Ruido</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>0.005</value></param>
<param><key>stop</key><value>1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>Ktx</value></param>
<param><key>value</key><value>int(math.pow(2,int(math.log(Ktx_d,2))))</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>Ktx_d</value></param>
<param><key>value</key><value>samp_rate_usrp_tx/samp_rate_d</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>Ktx_d_0</value></param>
<param><key>value</key><value>samp_rate_usrp_tx/samp_rate_d</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>M</value></param>
<param><key>value</key><value>len(Constelacion)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>N</value></param>
<param><key>value</key><value>32</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>N_c1</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>N_c2</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>N_c3</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>NbpCode</value></param>
<param><key>value</key><value>len(code)+10.</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>Nnou</value></param>
<param><key>value</key><value>N - N_c1 - N_c2 - N_c3</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>No_dB</value></param>
<param><key>value</key><value>-60</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>Pe</value></param>
<param><key>value</key><value>0.00001</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>Pr_subp</value></param>
<param><key>value</key><value>Es*Rs</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>Pt</value></param>
<param><key>value</key><value>Pt_subp*(N_c1+N_c2)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>Pt_dB</value></param>
<param><key>value</key><value>10*math.log(Pt,10)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>Pt_subp</value></param>
<param><key>value</key><value>Pr_subp*lfs</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>Rb_c1</value></param>
<param><key>value</key><value>1000000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>Rolloff</value></param>
<param><key>value</key><value>0.9</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>Rs</value></param>
<param><key>value</key><value>Rs_c1/N_c1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>Rs_c1</value></param>
<param><key>value</key><value>Rb_c1/Bps</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>Sps</value></param>
<param><key>value</key><value>2</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>code</value></param>
<param><key>value</key><value>'010110011011101100010101011111101001001110001011010001101010001'</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>landa</value></param>
<param><key>value</key><value>300000000./Fc</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>lfs</value></param>
<param><key>value</key><value>(4*math.pi*r_c1/landa)**2</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>payload</value></param>
<param><key>value</key><value>128</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>r_c1</value></param>
<param><key>value</key><value>8390</value></param>
</block>
<block>
<key>variable_qtgui_check_box</key>
<param><key>id</key><value>run_stop</value></param>
<param><key>value</key><value>True</value></param>
<param><key>false</key><value>False</value></param>
<param><key>gui_hint</key><value>0,0,1,1</value></param>
<param><key>label</key><value>Inicial/Parar</value></param>
<param><key>true</key><value>True</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>samp_rate_usrp_tx/Ktx</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate_d</value></param>
<param><key>value</key><value>Rs*N</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate_usrp_tx</value></param>
<param><key>value</key><value>400000000</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>P1</value></param>
<param><key>note</key><value>P1</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>P1_0</value></param>
<param><key>note</key><value>DATOS</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>P1_1</value></param>
<param><key>note</key><value>P2</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>P1_1_0</value></param>
<param><key>note</key><value>P3</value></param>
</block>
<block>
<key>analog_noise_source_x</key>
<param><key>id</key><value>analog_noise_source_x_0</value></param>
<param><key>amp</key><value>Kruido</value></param>
<param><key>noise_type</key><value>analog.GR_GAUSSIAN</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>seed</key><value>48</value></param>
</block>
<block>
<key>b_M_PAM_bb</key>
<param><key>id</key><value>b_M_PAM_bb_0</value></param>
<param><key>M</key><value>M</value></param>
<param><key>Nbps</key><value>8</value></param>
</block>
<block>
<key>b_M_PAM_bb</key>
<param><key>id</key><value>b_M_PAM_bb_0_0</value></param>
<param><key>M</key><value>M</value></param>
<param><key>Nbps</key><value>8</value></param>
</block>
<block>
<key>b_M_PAM_bb</key>
<param><key>id</key><value>b_M_PAM_bb_0_0_0</value></param>
<param><key>M</key><value>M</value></param>
<param><key>Nbps</key><value>8</value></param>
</block>
<block>
<key>b_PCM_Encoder_Bb</key>
<param><key>id</key><value>b_PCM_Encoder_Bb_0</value></param>
<param><key>code</key><value>code</value></param>
<param><key>payload</key><value>payload</value></param>
</block>
<block>
<key>b_PCM_Encoder_Bb</key>
<param><key>id</key><value>b_PCM_Encoder_Bb_0_0</value></param>
<param><key>code</key><value>code</value></param>
<param><key>payload</key><value>payload</value></param>
</block>
<block>
<key>b_PCM_Encoder_Bb</key>
<param><key>id</key><value>b_PCM_Encoder_Bb_0_0_0</value></param>
<param><key>code</key><value>code</value></param>
<param><key>payload</key><value>payload</value></param>
</block>
<block>
<key>blocks_add_xx</key>
<param><key>id</key><value>blocks_add_xx_0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_file_source</key>
<param><key>id</key><value>blocks_file_source_0</value></param>
<param><key>file</key><value>/home/comdig1/Dropbox/EnUbuntuFull/ClaseComDig/LibroAplicativos/capitulo 3/ExSI2017.Repeticion/solucion/texto1.txt</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>repeat</key><value>True</value></param>
</block>
<block>
<key>blocks_file_source</key>
<param><key>id</key><value>blocks_file_source_0_0</value></param>
<param><key>file</key><value>/home/comdig1/Dropbox/EnUbuntuFull/ClaseComDig/LibroAplicativos/capitulo 3/ExSI2017.Repeticion/solucion/texto2.txt</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>repeat</key><value>True</value></param>
</block>
<block>
<key>blocks_file_source</key>
<param><key>id</key><value>blocks_file_source_0_0_0</value></param>
<param><key>file</key><value>/home/comdig1/Dropbox/EnUbuntuFull/ClaseComDig/LibroAplicativos/capitulo 3/ExSI2017.Repeticion/solucion/texto3.txt</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>repeat</key><value>True</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0</value></param>
<param><key>const</key><value>1./N</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_0</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_inputs</key><value>N-8</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_1</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_1_0</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_null_source</key>
<param><key>id</key><value>blocks_null_source_0</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>num_outputs</key><value>Nnou+2</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_stream_to_streams</key>
<param><key>id</key><value>blocks_stream_to_streams_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_streams</key><value>N_c1</value></param>
</block>
<block>
<key>blocks_stream_to_vector</key>
<param><key>id</key><value>blocks_stream_to_vector_0_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_items</key><value>N</value></param>
</block>
<block>
<key>blocks_streams_to_vector</key>
<param><key>id</key><value>blocks_streams_to_vector_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_streams</key><value>N</value></param>
</block>
<block>
<key>blocks_vector_to_stream</key>
<param><key>id</key><value>blocks_vector_to_stream_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_items</key><value>N</value></param>
</block>
<block>
<key>blocks_vector_to_streams</key>
<param><key>id</key><value>blocks_vector_to_streams_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_streams</key><value>N</value></param>
</block>
<block>
<key>digital_chunks_to_symbols_xx</key>
<param><key>id</key><value>digital_chunks_to_symbols_xx_0</value></param>
<param><key>dimension</key><value>1</value></param>
<param><key>in_type</key><value>byte</value></param>
<param><key>out_type</key><value>complex</value></param>
<param><key>symbol_table</key><value>Constelacion</value></param>
</block>
<block>
<key>digital_chunks_to_symbols_xx</key>
<param><key>id</key><value>digital_chunks_to_symbols_xx_0_0</value></param>
<param><key>dimension</key><value>1</value></param>
<param><key>in_type</key><value>byte</value></param>
<param><key>out_type</key><value>complex</value></param>
<param><key>symbol_table</key><value>Constelacion</value></param>
</block>
<block>
<key>digital_chunks_to_symbols_xx</key>
<param><key>id</key><value>digital_chunks_to_symbols_xx_0_0_0</value></param>
<param><key>dimension</key><value>1</value></param>
<param><key>in_type</key><value>byte</value></param>
<param><key>out_type</key><value>complex</value></param>
<param><key>symbol_table</key><value>Constelacion</value></param>
</block>
<block>
<key>digital_diff_encoder_bb</key>
<param><key>id</key><value>digital_diff_encoder_bb_0</value></param>
<param><key>modulus</key><value>M</value></param>
</block>
<block>
<key>digital_diff_encoder_bb</key>
<param><key>id</key><value>digital_diff_encoder_bb_0_0</value></param>
<param><key>modulus</key><value>M</value></param>
</block>
<block>
<key>digital_diff_encoder_bb</key>
<param><key>id</key><value>digital_diff_encoder_bb_0_0_0</value></param>
<param><key>modulus</key><value>M</value></param>
</block>
<block>
<key>fft_vxx</key>
<param><key>id</key><value>fft_vxx_1</value></param>
<param><key>fft_size</key><value>N</value></param>
<param><key>forward</key><value>False</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>shift</key><value>False</value></param>
<param><key>window</key><value></value></param>
</block>
<block>
<key>fft_vxx</key>
<param><key>id</key><value>fft_vxx_1_0</value></param>
<param><key>fft_size</key><value>N</value></param>
<param><key>forward</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>shift</key><value>False</value></param>
<param><key>window</key><value></value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>import math</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0_1</value></param>
<param><key>import</key><value>import cmath</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0_1_0</value></param>
<param><key>import</key><value>import numpy</value></param>
</block>
<block>
<key>qtgui_tab_widget</key>
<param><key>id</key><value>pestana</value></param>
<param><key>gui_hint</key><value>3,0,1,3</value></param>
<param><key>label0</key><value>En el tiempo</value></param>
<param><key>label1</key><value>Constelacion</value></param>
<param><key>label2</key><value>Espectro Banda Base</value></param>
<param><key>label3</key><value>Espectro Paso Bandas</value></param>
<param><key>num_tabs</key><value>4</value></param>
</block>
<block>
<key>qtgui_const_sink_x</key>
<param><key>id</key><value>qtgui_const_sink_x_0_0</value></param>
<param><key>gui_hint</key><value>pestana@1:0,1,1,1</value></param>
<param><key>label1</key><value>Rx.Us0</value></param>
<param><key>style1</key><value>1</value></param>
<param><key>label2</key><value>Rx.Us1</value></param>
<param><key>label3</key><value>Rx.Us2</value></param>
<param><key>label4</key><value>Rx.Us3</value></param>
<param><key>label5</key><value>Rx.Us4</value></param>
<param><key>label6</key><value>Rx.Us5</value></param>
<param><key>label7</key><value>Rx.Us6</value></param>
<param><key>label8</key><value>Rx.Us7</value></param>
<param><key>nconnections</key><value>8</value></param>
<param><key>size</key><value>1024</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>qtgui_freq_sink_x</key>
<param><key>id</key><value>qtgui_freq_sink_x_0</value></param>
<param><key>average</key><value>0.05</value></param>
<param><key>bw</key><value>samp_rate</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>ctrlpanel</key><value>True</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>gui_hint</key><value>pestana@2:0,0,1,2</value></param>
<param><key>label1</key><value>Tx</value></param>
<param><key>width1</key><value>2</value></param>
<param><key>name</key><value>"PSD senal OFDM"</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>qtgui_freq_sink_x</key>
<param><key>id</key><value>qtgui_freq_sink_x_0_0</value></param>
<param><key>average</key><value>0.05</value></param>
<param><key>bw</key><value>samp_rate*2</value></param>
<param><key>fc</key><value>Fc</value></param>
<param><key>ctrlpanel</key><value>True</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>gui_hint</key><value>pestana@3:0,0,1,2</value></param>
<param><key>label1</key><value>Tx</value></param>
<param><key>width1</key><value>2</value></param>
<param><key>name</key><value>"PSD senal OFDM"</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>rational_resampler_xxx</key>
<param><key>id</key><value>rational_resampler_xxx_0_1</value></param>
<param><key>decim</key><value>samp_rate_d</value></param>
<param><key>interp</key><value>samp_rate</value></param>
<param><key>taps</key><value></value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_0</value></param>
<param><key>stream_id</key><value>o1</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_0_0</value></param>
<param><key>stream_id</key><value>o2</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_0_0_0</value></param>
<param><key>stream_id</key><value>c2</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_0_0_0_0</value></param>
<param><key>stream_id</key><value>c3</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_0_0_1_0_0</value></param>
<param><key>stream_id</key><value>sr1</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_0_0_1_0_0_0</value></param>
<param><key>stream_id</key><value>sr0</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_0_0_1_0_0_0_0</value></param>
<param><key>stream_id</key><value>sr2</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_0_0_1_0_0_0_0_0</value></param>
<param><key>stream_id</key><value>sr6</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_0_0_1_0_0_0_1</value></param>
<param><key>stream_id</key><value>sr4</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_0_0_1_0_0_1</value></param>
<param><key>stream_id</key><value>sr3</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_0_0_1_0_0_1_0</value></param>
<param><key>stream_id</key><value>sr7</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_0_0_1_0_0_2</value></param>
<param><key>stream_id</key><value>sr5</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_0_1</value></param>
<param><key>stream_id</key><value>c1</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_0</value></param>
<param><key>stream_id</key><value>c1</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_0_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>stream_id</key><value>c2</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_0_0_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>stream_id</key><value>c3</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>vs_1</value></param>
<param><key>stream_id</key><value>o1</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>vs_1_1_0</value></param>
<param><key>stream_id</key><value>sr0</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>vs_1_1_0_0</value></param>
<param><key>stream_id</key><value>sr1</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>vs_1_1_0_0_0</value></param>
<param><key>stream_id</key><value>sr5</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>vs_1_1_0_1</value></param>
<param><key>stream_id</key><value>sr2</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>vs_1_1_0_1_0</value></param>
<param><key>stream_id</key><value>sr6</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>vs_1_1_0_2</value></param>
<param><key>stream_id</key><value>sr3</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>vs_1_1_0_2_0</value></param>
<param><key>stream_id</key><value>sr7</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>vs_1_1_0_3</value></param>
<param><key>stream_id</key><value>sr4</value></param>
</block>
<connection><source_block_id>analog_noise_source_x_0</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>b_M_PAM_bb_0</source_block_id><sink_block_id>digital_diff_encoder_bb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>b_M_PAM_bb_0_0</source_block_id><sink_block_id>digital_diff_encoder_bb_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>b_M_PAM_bb_0_0_0</source_block_id><sink_block_id>digital_diff_encoder_bb_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>b_PCM_Encoder_Bb_0</source_block_id><sink_block_id>b_M_PAM_bb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>b_PCM_Encoder_Bb_0_0</source_block_id><sink_block_id>b_M_PAM_bb_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>b_PCM_Encoder_Bb_0_0_0</source_block_id><sink_block_id>b_M_PAM_bb_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_add_xx_0</source_block_id><sink_block_id>blocks_stream_to_vector_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_add_xx_0</source_block_id><sink_block_id>virtual_sink_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_file_source_0</source_block_id><sink_block_id>b_PCM_Encoder_Bb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_file_source_0_0</source_block_id><sink_block_id>b_PCM_Encoder_Bb_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_file_source_0_0_0</source_block_id><sink_block_id>b_PCM_Encoder_Bb_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0</source_block_id><sink_block_id>rational_resampler_xxx_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_null_source_0</source_block_id><sink_block_id>blocks_streams_to_vector_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_null_source_0</source_block_id><sink_block_id>blocks_streams_to_vector_0</sink_block_id><source_key>1</source_key><sink_key>30</sink_key></connection>
<connection><source_block_id>blocks_null_source_0</source_block_id><sink_block_id>blocks_streams_to_vector_0</sink_block_id><source_key>10</source_key><sink_key>10</sink_key></connection>
<connection><source_block_id>blocks_null_source_0</source_block_id><sink_block_id>blocks_streams_to_vector_0</sink_block_id><source_key>11</source_key><sink_key>11</sink_key></connection>
<connection><source_block_id>blocks_null_source_0</source_block_id><sink_block_id>blocks_streams_to_vector_0</sink_block_id><source_key>12</source_key><sink_key>12</sink_key></connection>
<connection><source_block_id>blocks_null_source_0</source_block_id><sink_block_id>blocks_streams_to_vector_0</sink_block_id><source_key>13</source_key><sink_key>13</sink_key></connection>
<connection><source_block_id>blocks_null_source_0</source_block_id><sink_block_id>blocks_streams_to_vector_0</sink_block_id><source_key>14</source_key><sink_key>14</sink_key></connection>
<connection><source_block_id>blocks_null_source_0</source_block_id><sink_block_id>blocks_streams_to_vector_0</sink_block_id><source_key>15</source_key><sink_key>15</sink_key></connection>
<connection><source_block_id>blocks_null_source_0</source_block_id><sink_block_id>blocks_streams_to_vector_0</sink_block_id><source_key>16</source_key><sink_key>24</sink_key></connection>
<connection><source_block_id>blocks_null_source_0</source_block_id><sink_block_id>blocks_streams_to_vector_0</sink_block_id><source_key>17</source_key><sink_key>25</sink_key></connection>
<connection><source_block_id>blocks_null_source_0</source_block_id><sink_block_id>blocks_streams_to_vector_0</sink_block_id><source_key>18</source_key><sink_key>26</sink_key></connection>
<connection><source_block_id>blocks_null_source_0</source_block_id><sink_block_id>blocks_streams_to_vector_0</sink_block_id><source_key>19</source_key><sink_key>27</sink_key></connection>
<connection><source_block_id>blocks_null_source_0</source_block_id><sink_block_id>blocks_streams_to_vector_0</sink_block_id><source_key>2</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>blocks_null_source_0</source_block_id><sink_block_id>blocks_streams_to_vector_0</sink_block_id><source_key>20</source_key><sink_key>28</sink_key></connection>
<connection><source_block_id>blocks_null_source_0</source_block_id><sink_block_id>blocks_streams_to_vector_0</sink_block_id><source_key>21</source_key><sink_key>29</sink_key></connection>
<connection><source_block_id>blocks_null_source_0</source_block_id><sink_block_id>blocks_streams_to_vector_0</sink_block_id><source_key>22</source_key><sink_key>17</sink_key></connection>
<connection><source_block_id>blocks_null_source_0</source_block_id><sink_block_id>blocks_streams_to_vector_0</sink_block_id><source_key>23</source_key><sink_key>18</sink_key></connection>
<connection><source_block_id>blocks_null_source_0</source_block_id><sink_block_id>blocks_streams_to_vector_0</sink_block_id><source_key>24</source_key><sink_key>19</sink_key></connection>
<connection><source_block_id>blocks_null_source_0</source_block_id><sink_block_id>blocks_streams_to_vector_0</sink_block_id><source_key>25</source_key><sink_key>20</sink_key></connection>
<connection><source_block_id>blocks_null_source_0</source_block_id><sink_block_id>blocks_streams_to_vector_0</sink_block_id><source_key>26</source_key><sink_key>21</sink_key></connection>
<connection><source_block_id>blocks_null_source_0</source_block_id><sink_block_id>blocks_streams_to_vector_0</sink_block_id><source_key>27</source_key><sink_key>22</sink_key></connection>
<connection><source_block_id>blocks_null_source_0</source_block_id><sink_block_id>blocks_streams_to_vector_0</sink_block_id><source_key>28</source_key><sink_key>23</sink_key></connection>
<connection><source_block_id>blocks_null_source_0</source_block_id><sink_block_id>blocks_streams_to_vector_0</sink_block_id><source_key>29</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_null_source_0</source_block_id><sink_block_id>blocks_streams_to_vector_0</sink_block_id><source_key>3</source_key><sink_key>3</sink_key></connection>
<connection><source_block_id>blocks_null_source_0</source_block_id><sink_block_id>blocks_streams_to_vector_0</sink_block_id><source_key>30</source_key><sink_key>31</sink_key></connection>
<connection><source_block_id>blocks_null_source_0</source_block_id><sink_block_id>blocks_streams_to_vector_0</sink_block_id><source_key>4</source_key><sink_key>4</sink_key></connection>
<connection><source_block_id>blocks_null_source_0</source_block_id><sink_block_id>blocks_streams_to_vector_0</sink_block_id><source_key>5</source_key><sink_key>5</sink_key></connection>
<connection><source_block_id>blocks_null_source_0</source_block_id><sink_block_id>blocks_streams_to_vector_0</sink_block_id><source_key>6</source_key><sink_key>6</sink_key></connection>
<connection><source_block_id>blocks_null_source_0</source_block_id><sink_block_id>blocks_streams_to_vector_0</sink_block_id><source_key>7</source_key><sink_key>7</sink_key></connection>
<connection><source_block_id>blocks_null_source_0</source_block_id><sink_block_id>blocks_streams_to_vector_0</sink_block_id><source_key>8</source_key><sink_key>8</sink_key></connection>
<connection><source_block_id>blocks_null_source_0</source_block_id><sink_block_id>blocks_streams_to_vector_0</sink_block_id><source_key>9</source_key><sink_key>9</sink_key></connection>
<connection><source_block_id>blocks_stream_to_streams_0</source_block_id><sink_block_id>blocks_streams_to_vector_0</sink_block_id><source_key>0</source_key><sink_key>16</sink_key></connection>
<connection><source_block_id>blocks_stream_to_vector_0_0</source_block_id><sink_block_id>fft_vxx_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_streams_to_vector_0</source_block_id><sink_block_id>fft_vxx_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vector_to_stream_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vector_to_streams_0</source_block_id><sink_block_id>virtual_sink_0_0_1_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vector_to_streams_0</source_block_id><sink_block_id>virtual_sink_0_0_1_0_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vector_to_streams_0</source_block_id><sink_block_id>blocks_null_sink_0</sink_block_id><source_key>10</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>blocks_vector_to_streams_0</source_block_id><sink_block_id>blocks_null_sink_0</sink_block_id><source_key>11</source_key><sink_key>3</sink_key></connection>
<connection><source_block_id>blocks_vector_to_streams_0</source_block_id><sink_block_id>blocks_null_sink_0</sink_block_id><source_key>12</source_key><sink_key>4</sink_key></connection>
<connection><source_block_id>blocks_vector_to_streams_0</source_block_id><sink_block_id>blocks_null_sink_0</sink_block_id><source_key>13</source_key><sink_key>5</sink_key></connection>
<connection><source_block_id>blocks_vector_to_streams_0</source_block_id><sink_block_id>blocks_null_sink_0</sink_block_id><source_key>14</source_key><sink_key>6</sink_key></connection>
<connection><source_block_id>blocks_vector_to_streams_0</source_block_id><sink_block_id>blocks_null_sink_0</sink_block_id><source_key>15</source_key><sink_key>7</sink_key></connection>
<connection><source_block_id>blocks_vector_to_streams_0</source_block_id><sink_block_id>blocks_null_sink_0</sink_block_id><source_key>16</source_key><sink_key>8</sink_key></connection>
<connection><source_block_id>blocks_vector_to_streams_0</source_block_id><sink_block_id>blocks_null_sink_0</sink_block_id><source_key>17</source_key><sink_key>9</sink_key></connection>
<connection><source_block_id>blocks_vector_to_streams_0</source_block_id><sink_block_id>blocks_null_sink_0</sink_block_id><source_key>18</source_key><sink_key>10</sink_key></connection>
<connection><source_block_id>blocks_vector_to_streams_0</source_block_id><sink_block_id>blocks_null_sink_0</sink_block_id><source_key>19</source_key><sink_key>11</sink_key></connection>
<connection><source_block_id>blocks_vector_to_streams_0</source_block_id><sink_block_id>virtual_sink_0_0_1_0_0_0_0</sink_block_id><source_key>2</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vector_to_streams_0</source_block_id><sink_block_id>blocks_null_sink_0</sink_block_id><source_key>20</source_key><sink_key>12</sink_key></connection>
<connection><source_block_id>blocks_vector_to_streams_0</source_block_id><sink_block_id>blocks_null_sink_0</sink_block_id><source_key>21</source_key><sink_key>13</sink_key></connection>
<connection><source_block_id>blocks_vector_to_streams_0</source_block_id><sink_block_id>blocks_null_sink_0</sink_block_id><source_key>22</source_key><sink_key>14</sink_key></connection>
<connection><source_block_id>blocks_vector_to_streams_0</source_block_id><sink_block_id>blocks_null_sink_0</sink_block_id><source_key>23</source_key><sink_key>15</sink_key></connection>
<connection><source_block_id>blocks_vector_to_streams_0</source_block_id><sink_block_id>blocks_null_sink_0</sink_block_id><source_key>24</source_key><sink_key>16</sink_key></connection>
<connection><source_block_id>blocks_vector_to_streams_0</source_block_id><sink_block_id>blocks_null_sink_0</sink_block_id><source_key>25</source_key><sink_key>17</sink_key></connection>
<connection><source_block_id>blocks_vector_to_streams_0</source_block_id><sink_block_id>blocks_null_sink_0</sink_block_id><source_key>26</source_key><sink_key>18</sink_key></connection>
<connection><source_block_id>blocks_vector_to_streams_0</source_block_id><sink_block_id>blocks_null_sink_0</sink_block_id><source_key>27</source_key><sink_key>19</sink_key></connection>
<connection><source_block_id>blocks_vector_to_streams_0</source_block_id><sink_block_id>blocks_null_sink_0</sink_block_id><source_key>28</source_key><sink_key>20</sink_key></connection>
<connection><source_block_id>blocks_vector_to_streams_0</source_block_id><sink_block_id>blocks_null_sink_0</sink_block_id><source_key>29</source_key><sink_key>21</sink_key></connection>
<connection><source_block_id>blocks_vector_to_streams_0</source_block_id><sink_block_id>virtual_sink_0_0_1_0_0_1</sink_block_id><source_key>3</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vector_to_streams_0</source_block_id><sink_block_id>blocks_null_sink_0</sink_block_id><source_key>30</source_key><sink_key>22</sink_key></connection>
<connection><source_block_id>blocks_vector_to_streams_0</source_block_id><sink_block_id>blocks_null_sink_0</sink_block_id><source_key>31</source_key><sink_key>23</sink_key></connection>
<connection><source_block_id>blocks_vector_to_streams_0</source_block_id><sink_block_id>virtual_sink_0_0_1_0_0_0_1</sink_block_id><source_key>4</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vector_to_streams_0</source_block_id><sink_block_id>virtual_sink_0_0_1_0_0_2</sink_block_id><source_key>5</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vector_to_streams_0</source_block_id><sink_block_id>virtual_sink_0_0_1_0_0_0_0_0</sink_block_id><source_key>6</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vector_to_streams_0</source_block_id><sink_block_id>virtual_sink_0_0_1_0_0_1_0</sink_block_id><source_key>7</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vector_to_streams_0</source_block_id><sink_block_id>blocks_null_sink_0</sink_block_id><source_key>8</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vector_to_streams_0</source_block_id><sink_block_id>blocks_null_sink_0</sink_block_id><source_key>9</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>digital_chunks_to_symbols_xx_0</source_block_id><sink_block_id>virtual_sink_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_chunks_to_symbols_xx_0_0</source_block_id><sink_block_id>blocks_null_sink_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_chunks_to_symbols_xx_0_0</source_block_id><sink_block_id>virtual_sink_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_chunks_to_symbols_xx_0_0_0</source_block_id><sink_block_id>blocks_null_sink_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_chunks_to_symbols_xx_0_0_0</source_block_id><sink_block_id>virtual_sink_0_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_diff_encoder_bb_0</source_block_id><sink_block_id>digital_chunks_to_symbols_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_diff_encoder_bb_0_0</source_block_id><sink_block_id>digital_chunks_to_symbols_xx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_diff_encoder_bb_0_0_0</source_block_id><sink_block_id>digital_chunks_to_symbols_xx_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fft_vxx_1</source_block_id><sink_block_id>blocks_vector_to_stream_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fft_vxx_1_0</source_block_id><sink_block_id>blocks_vector_to_streams_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rational_resampler_xxx_0_1</source_block_id><sink_block_id>virtual_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_0</source_block_id><sink_block_id>blocks_stream_to_streams_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_0_0</source_block_id><sink_block_id>blocks_streams_to_vector_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>virtual_source_0_0_0</source_block_id><sink_block_id>blocks_streams_to_vector_0</sink_block_id><source_key>0</source_key><sink_key>31</sink_key></connection>
<connection><source_block_id>vs_1</source_block_id><sink_block_id>qtgui_freq_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>vs_1</source_block_id><sink_block_id>qtgui_freq_sink_x_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>vs_1_1_0</source_block_id><sink_block_id>qtgui_const_sink_x_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>vs_1_1_0_0</source_block_id><sink_block_id>qtgui_const_sink_x_0_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>vs_1_1_0_0_0</source_block_id><sink_block_id>qtgui_const_sink_x_0_0</sink_block_id><source_key>0</source_key><sink_key>5</sink_key></connection>
<connection><source_block_id>vs_1_1_0_1</source_block_id><sink_block_id>qtgui_const_sink_x_0_0</sink_block_id><source_key>0</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>vs_1_1_0_1_0</source_block_id><sink_block_id>qtgui_const_sink_x_0_0</sink_block_id><source_key>0</source_key><sink_key>6</sink_key></connection>
<connection><source_block_id>vs_1_1_0_2</source_block_id><sink_block_id>qtgui_const_sink_x_0_0</sink_block_id><source_key>0</source_key><sink_key>3</sink_key></connection>
<connection><source_block_id>vs_1_1_0_2_0</source_block_id><sink_block_id>qtgui_const_sink_x_0_0</sink_block_id><source_key>0</source_key><sink_key>7</sink_key></connection>
<connection><source_block_id>vs_1_1_0_3</source_block_id><sink_block_id>qtgui_const_sink_x_0_0</sink_block_id><source_key>0</source_key><sink_key>4</sink_key></connection>
</flow_graph>
