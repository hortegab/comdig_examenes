<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.9'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>Lab_total</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>run</key><value>run_stop</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>B_usrp</value></param>
<param><key>value</key><value>samp_rate</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>Bps</value></param>
<param><key>value</key><value>int(math.log(M,2))</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>Ch_Delay</value></param>
<param><key>value</key><value>0</value></param>
<param><key>gui_hint</key><value>controls@0:0,2,1,1</value></param>
<param><key>label</key><value>Ch_Delay</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>1000</value></param>
<param><key>rangeType</key><value>int</value></param>
<param><key>widget</key><value>counter</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>Ch_Frec_offset</value></param>
<param><key>value</key><value>0</value></param>
<param><key>gui_hint</key><value>controls@0:0,1,1,1</value></param>
<param><key>label</key><value>Ch_Frec_offset (Hz)</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>0.01</value></param>
<param><key>stop</key><value>100</value></param>
<param><key>widget</key><value>counter</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>Ch_Jitter</value></param>
<param><key>value</key><value>0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>gui_hint</key><value>controls@0:0,3,1,1</value></param>
<param><key>label</key><value>Ch_Jitter</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>-.9</value></param>
<param><key>step</key><value>0.01</value></param>
<param><key>stop</key><value>.9</value></param>
<param><key>widget</key><value>slider</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>Ch_taps</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>value</key><value>fftpack.ifftshift(fftpack.ifft([tap3, tap4, 1.0, tap1, tap2]))</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>Constelacion</value></param>
<param><key>value</key><value>[1.+0.j,   0.+1.j,   -1.+0.j,  0.-1.j ]</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>Fc</value></param>
<param><key>value</key><value>900e6</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>Gain_USRP_Rx_dB</value></param>
<param><key>value</key><value>0.</value></param>
<param><key>gui_hint</key><value>controls@2:0,2,1,1</value></param>
<param><key>label</key><value>Gain_USRP_Rx (dB)</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0.</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>130</value></param>
<param><key>widget</key><value>counter</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>Gain_USRP_Tx_dB</value></param>
<param><key>value</key><value>30.</value></param>
<param><key>gui_hint</key><value>controls@2:0,1,1,1</value></param>
<param><key>label</key><value>Gain_USRP_Tx (dB)</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0.</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>130</value></param>
<param><key>widget</key><value>counter</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>Kd</value></param>
<param><key>value</key><value>512</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>M</value></param>
<param><key>value</key><value>len(Constelacion)</value></param>
</block>
<block>
<key>variable_constellation</key>
<param><key>id</key><value>MiconstellationObject</value></param>
<param><key>const_points</key><value>Constelacion</value></param>
<param><key>dims</key><value>1</value></param>
<param><key>rot_sym</key><value>4</value></param>
<param><key>precision</key><value>8</value></param>
<param><key>sym_map</key><value></value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>N</value></param>
<param><key>value</key><value>8</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>NbpCode</value></param>
<param><key>value</key><value>len(code1)+10.</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>NodB</value></param>
<param><key>value</key><value>-63</value></param>
<param><key>gui_hint</key><value>controls@0:0,0,1,1</value></param>
<param><key>label</key><value>Ch_No(dB)</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>-140.</value></param>
<param><key>step</key><value>1.</value></param>
<param><key>stop</key><value>0.</value></param>
<param><key>widget</key><value>counter</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>Rb</value></param>
<param><key>value</key><value>Rs*Bps</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>Rbi</value></param>
<param><key>value</key><value>Rb/(1+NbpCode/payload)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>Rs</value></param>
<param><key>value</key><value>Rs_subchannel*N</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>Rs_subchannel</value></param>
<param><key>value</key><value>B_usrp/N</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>SymbTune</value></param>
<param><key>value</key><value>2</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>gui_hint</key><value>controls@2:0,0,1,1</value></param>
<param><key>label</key><value>SymbTuning</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>1000</value></param>
<param><key>rangeType</key><value>int</value></param>
<param><key>widget</key><value>counter</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>Tmax_scope</value></param>
<param><key>value</key><value>64./Rs</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>code1</value></param>
<param><key>value</key><value>'010110011011101100010101011111101001001110001011010001101010001'</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>eq_gain</value></param>
<param><key>value</key><value>0.01</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>payload</value></param>
<param><key>value</key><value>128</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>phi</value></param>
<param><key>value</key><value>0.</value></param>
<param><key>gui_hint</key><value>controls@0:0,3,1,1</value></param>
<param><key>label</key><value>Angulo</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>-numpy.pi</value></param>
<param><key>step</key><value>numpy.pi/100.</value></param>
<param><key>stop</key><value>numpy.pi</value></param>
</block>
<block>
<key>variable_qtgui_check_box</key>
<param><key>id</key><value>run_stop</value></param>
<param><key>value</key><value>True</value></param>
<param><key>false</key><value>False</value></param>
<param><key>gui_hint</key><value>0,0,1,1</value></param>
<param><key>label</key><value>Inicial/Parar</value></param>
<param><key>true</key><value>True</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>int(samp_rate_usrp_rx/Kd)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate_usrp_rx</value></param>
<param><key>value</key><value>100e6</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>tap1</value></param>
<param><key>value</key><value>0.25</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>gui_hint</key><value>controls@1:0,0,1,1</value></param>
<param><key>orient</key><value>Qt.Vertical</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>0.01</value></param>
<param><key>stop</key><value>1</value></param>
<param><key>widget</key><value>slider</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>tap2</value></param>
<param><key>value</key><value>1</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>gui_hint</key><value>controls@1:0,1,1,1</value></param>
<param><key>orient</key><value>Qt.Vertical</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>0.01</value></param>
<param><key>stop</key><value>1</value></param>
<param><key>widget</key><value>slider</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>tap3</value></param>
<param><key>value</key><value>1</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>gui_hint</key><value>controls@1:0,2,1,1</value></param>
<param><key>orient</key><value>Qt.Vertical</value></param>
<param><key>start</key><value>0.25</value></param>
<param><key>step</key><value>0.01</value></param>
<param><key>stop</key><value>1</value></param>
<param><key>widget</key><value>slider</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>tap4</value></param>
<param><key>value</key><value>1</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>gui_hint</key><value>controls@1:0,3,1,1</value></param>
<param><key>orient</key><value>Qt.Vertical</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>0.01</value></param>
<param><key>stop</key><value>1</value></param>
<param><key>widget</key><value>slider</value></param>
</block>
<block>
<key>qtgui_tab_widget</key>
<param><key>id</key><value>Instrumentos</value></param>
<param><key>gui_hint</key><value>1,0,1,2</value></param>
<param><key>label0</key><value>Capa0.Canal y precanal</value></param>
<param><key>label1</key><value>Capas.Pre-modulacion</value></param>
<param><key>label2</key><value>Capa1. Modulacion</value></param>
<param><key>label3</key><value>Capa2. CodificacionDeSimbolos</value></param>
<param><key>num_tabs</key><value>4</value></param>
</block>
<block>
<key>qtgui_tab_widget</key>
<param><key>id</key><value>Pre_modulacion</value></param>
<param><key>gui_hint</key><value>Instrumentos@1:1,0,1,1</value></param>
<param><key>label0</key><value>Capa8.Mensaje continuo</value></param>
<param><key>label1</key><value>Capa7.Cuantificacion</value></param>
<param><key>label2</key><value>Capa6.PCM</value></param>
<param><key>label3</key><value>Capa5.Otrastecnicas</value></param>
<param><key>label4</key><value>Capa4.CodificacionBinaria</value></param>
<param><key>label5</key><value>Capa3.M-PAM</value></param>
<param><key>num_tabs</key><value>6</value></param>
</block>
<block>
<key>b_M_PAM_bb</key>
<param><key>id</key><value>b_M_PAM_bb_0</value></param>
<param><key>M</key><value>M</value></param>
<param><key>Nbps</key><value>8</value></param>
</block>
<block>
<key>b_M_PAM_bb</key>
<param><key>id</key><value>b_M_PAM_bb_0_0</value></param>
<param><key>M</key><value>M</value></param>
<param><key>Nbps</key><value>8</value></param>
</block>
<block>
<key>b_PCM_Encoder_Bb</key>
<param><key>id</key><value>b_PCM_Encoder_Bb_0</value></param>
<param><key>code</key><value>code1</value></param>
<param><key>payload</key><value>payload</value></param>
</block>
<block>
<key>b_PCM_Encoder_Bb</key>
<param><key>id</key><value>b_PCM_Encoder_Bb_0_0</value></param>
<param><key>code</key><value>code1</value></param>
<param><key>payload</key><value>payload</value></param>
</block>
<block>
<key>blocks_file_source</key>
<param><key>id</key><value>blocks_file_source_0</value></param>
<param><key>file</key><value>/home/comdig1/Dropbox/EnUbuntuFull/ClaseComDig/LibroAplicativos/capitulo 3/Lab3.1.ofdm2/texto1.txt</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>repeat</key><value>True</value></param>
</block>
<block>
<key>blocks_file_source</key>
<param><key>id</key><value>blocks_file_source_0_0</value></param>
<param><key>file</key><value>/home/comdig1/Dropbox/EnUbuntuFull/ClaseComDig/LibroAplicativos/capitulo 3/Lab3.1.ofdm2/texto1.txt</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>repeat</key><value>True</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0</value></param>
<param><key>const</key><value>1./N</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_stream_to_streams</key>
<param><key>id</key><value>blocks_stream_to_streams_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_streams</key><value>5</value></param>
</block>
<block>
<key>blocks_stream_to_streams</key>
<param><key>id</key><value>blocks_stream_to_streams_0_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_streams</key><value>3</value></param>
</block>
<block>
<key>blocks_streams_to_vector</key>
<param><key>id</key><value>blocks_streams_to_vector_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_streams</key><value>8</value></param>
</block>
<block>
<key>blocks_vector_to_stream</key>
<param><key>id</key><value>blocks_vector_to_stream_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_items</key><value>N</value></param>
</block>
<block>
<key>qtgui_tab_widget</key>
<param><key>id</key><value>canal</value></param>
<param><key>gui_hint</key><value>Instrumentos@0:1,0,1,1</value></param>
<param><key>label0</key><value>Constelacion</value></param>
<param><key>label1</key><value>Espectro</value></param>
<param><key>label2</key><value>Medidores</value></param>
<param><key>label3</key><value>Tiempo</value></param>
<param><key>num_tabs</key><value>4</value></param>
</block>
<block>
<key>qtgui_tab_widget</key>
<param><key>id</key><value>controls</value></param>
<param><key>gui_hint</key><value>0,1,1,1</value></param>
<param><key>label0</key><value>Ch_Offsets</value></param>
<param><key>label1</key><value>Ch_Taps</value></param>
<param><key>label2</key><value>Tuning</value></param>
<param><key>num_tabs</key><value>3</value></param>
</block>
<block>
<key>digital_chunks_to_symbols_xx</key>
<param><key>id</key><value>digital_chunks_to_symbols_xx_0</value></param>
<param><key>dimension</key><value>1</value></param>
<param><key>in_type</key><value>byte</value></param>
<param><key>out_type</key><value>complex</value></param>
<param><key>symbol_table</key><value>Constelacion</value></param>
</block>
<block>
<key>digital_chunks_to_symbols_xx</key>
<param><key>id</key><value>digital_chunks_to_symbols_xx_0_0</value></param>
<param><key>dimension</key><value>1</value></param>
<param><key>in_type</key><value>byte</value></param>
<param><key>out_type</key><value>complex</value></param>
<param><key>symbol_table</key><value>Constelacion</value></param>
</block>
<block>
<key>digital_diff_encoder_bb</key>
<param><key>id</key><value>digital_diff_encoder_bb_0</value></param>
<param><key>modulus</key><value>M</value></param>
</block>
<block>
<key>digital_diff_encoder_bb</key>
<param><key>id</key><value>digital_diff_encoder_bb_0_0</value></param>
<param><key>modulus</key><value>M</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>e1_0_0_0_1_0_0_0_0</value></param>
<param><key>stream_id</key><value>R1</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>e1_0_0_0_1_0_0_0_0_2</value></param>
<param><key>stream_id</key><value>T1</value></param>
</block>
<block>
<key>fft_vxx</key>
<param><key>id</key><value>fft_vxx_1</value></param>
<param><key>fft_size</key><value>N</value></param>
<param><key>forward</key><value>False</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>shift</key><value>False</value></param>
<param><key>window</key><value></value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0_1</value></param>
<param><key>import</key><value>import cmath</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0_1_0</value></param>
<param><key>import</key><value>import numpy</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0_1_0_0</value></param>
<param><key>import</key><value>import random</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0_1_1</value></param>
<param><key>import</key><value>import math</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_scipy</value></param>
<param><key>import</key><value>from scipy import fftpack</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_0_0_1</value></param>
<param><key>note</key><value>CAPA0 CANAL</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_0_0_1_2</value></param>
<param><key>note</key><value>INSTRUMENTACION</value></param>
</block>
<block>
<key>qtgui_const_sink_x</key>
<param><key>id</key><value>qtgui_const_sink_x_0_1</value></param>
<param><key>gui_hint</key><value>canal@0:1,1,1,1</value></param>
<param><key>label1</key><value>Rx.R1</value></param>
<param><key>style1</key><value>1</value></param>
<param><key>name</key><value>"Rx"</value></param>
<param><key>size</key><value>1024</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>qtgui_const_sink_x</key>
<param><key>id</key><value>qtgui_const_sink_x_0_1_2</value></param>
<param><key>gui_hint</key><value>canal@0:1,0,1,1</value></param>
<param><key>label1</key><value>Tx.T1</value></param>
<param><key>style1</key><value>1</value></param>
<param><key>name</key><value>"Tx"</value></param>
<param><key>size</key><value>1024</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>qtgui_freq_sink_x</key>
<param><key>id</key><value>qtgui_freq_sink_x_0</value></param>
<param><key>average</key><value>0.05</value></param>
<param><key>bw</key><value>Rs</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>gui_hint</key><value>canal@1:0,1,1,1</value></param>
<param><key>label1</key><value>Rx.R1</value></param>
<param><key>width1</key><value>2</value></param>
<param><key>name</key><value>"PSD Banda Base"</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>qtgui_freq_sink_x</key>
<param><key>id</key><value>qtgui_freq_sink_x_0_0</value></param>
<param><key>average</key><value>0.05</value></param>
<param><key>bw</key><value>Rs*2</value></param>
<param><key>fc</key><value>Fc</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>gui_hint</key><value>canal@1:0,2,1,1</value></param>
<param><key>label1</key><value>Rx.R1</value></param>
<param><key>width1</key><value>2</value></param>
<param><key>name</key><value>"PSD Paso Bandas"</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0</value></param>
<param><key>gui_hint</key><value>canal@3:0,0,1,1</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>color2</key><value>"red"</value></param>
<param><key>label2</key><value></value></param>
<param><key>name</key><value>"RX.R1"</value></param>
<param><key>size</key><value>32</value></param>
<param><key>srate</key><value>samp_rate</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>rational_resampler_xxx</key>
<param><key>id</key><value>rational_resampler_xxx_0</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>interp</key><value>2</value></param>
<param><key>taps</key><value></value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<block>
<key>uhd_usrp_sink</key>
<param><key>id</key><value>uhd_usrp_sink_0</value></param>
<param><key>ant0</key><value>TX/RX</value></param>
<param><key>center_freq0</key><value>Fc</value></param>
<param><key>norm_gain0</key><value>False</value></param>
<param><key>gain0</key><value>Gain_USRP_Tx_dB</value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>dev_args</key><value>""</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>hide_cmd_port</key><value>False</value></param>
<param><key>sync</key><value></value></param>
<param><key>len_tag_name</key><value></value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_0</value></param>
<param><key>stream_id</key><value>c1</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_0_0</value></param>
<param><key>stream_id</key><value>c2</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_0</value></param>
<param><key>stream_id</key><value>c1</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_0_0</value></param>
<param><key>stream_id</key><value>c1</value></param>
</block>
<connection><source_block_id>b_M_PAM_bb_0</source_block_id><sink_block_id>digital_diff_encoder_bb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>b_M_PAM_bb_0_0</source_block_id><sink_block_id>digital_diff_encoder_bb_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>b_PCM_Encoder_Bb_0</source_block_id><sink_block_id>b_M_PAM_bb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>b_PCM_Encoder_Bb_0_0</source_block_id><sink_block_id>b_M_PAM_bb_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_file_source_0</source_block_id><sink_block_id>b_PCM_Encoder_Bb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_file_source_0_0</source_block_id><sink_block_id>b_PCM_Encoder_Bb_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0</source_block_id><sink_block_id>uhd_usrp_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_to_streams_0</source_block_id><sink_block_id>blocks_streams_to_vector_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_to_streams_0</source_block_id><sink_block_id>blocks_streams_to_vector_0</sink_block_id><source_key>1</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_stream_to_streams_0</source_block_id><sink_block_id>blocks_streams_to_vector_0</sink_block_id><source_key>2</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>blocks_stream_to_streams_0</source_block_id><sink_block_id>blocks_streams_to_vector_0</sink_block_id><source_key>3</source_key><sink_key>3</sink_key></connection>
<connection><source_block_id>blocks_stream_to_streams_0</source_block_id><sink_block_id>blocks_streams_to_vector_0</sink_block_id><source_key>4</source_key><sink_key>4</sink_key></connection>
<connection><source_block_id>blocks_stream_to_streams_0_0</source_block_id><sink_block_id>blocks_streams_to_vector_0</sink_block_id><source_key>0</source_key><sink_key>5</sink_key></connection>
<connection><source_block_id>blocks_stream_to_streams_0_0</source_block_id><sink_block_id>blocks_streams_to_vector_0</sink_block_id><source_key>1</source_key><sink_key>6</sink_key></connection>
<connection><source_block_id>blocks_stream_to_streams_0_0</source_block_id><sink_block_id>blocks_streams_to_vector_0</sink_block_id><source_key>2</source_key><sink_key>7</sink_key></connection>
<connection><source_block_id>blocks_streams_to_vector_0</source_block_id><sink_block_id>fft_vxx_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vector_to_stream_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_chunks_to_symbols_xx_0</source_block_id><sink_block_id>virtual_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_chunks_to_symbols_xx_0_0</source_block_id><sink_block_id>virtual_sink_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_diff_encoder_bb_0</source_block_id><sink_block_id>digital_chunks_to_symbols_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_diff_encoder_bb_0_0</source_block_id><sink_block_id>digital_chunks_to_symbols_xx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>e1_0_0_0_1_0_0_0_0</source_block_id><sink_block_id>qtgui_const_sink_x_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>e1_0_0_0_1_0_0_0_0</source_block_id><sink_block_id>qtgui_freq_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>e1_0_0_0_1_0_0_0_0</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>e1_0_0_0_1_0_0_0_0</source_block_id><sink_block_id>rational_resampler_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>e1_0_0_0_1_0_0_0_0_2</source_block_id><sink_block_id>qtgui_const_sink_x_0_1_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fft_vxx_1</source_block_id><sink_block_id>blocks_vector_to_stream_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rational_resampler_xxx_0</source_block_id><sink_block_id>qtgui_freq_sink_x_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_0</source_block_id><sink_block_id>blocks_stream_to_streams_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_0_0</source_block_id><sink_block_id>blocks_stream_to_streams_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
